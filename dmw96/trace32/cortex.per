base a:0x0
group 00--00
textline " +-----------------------------------------------------------------+"
textline " | Lauterbach peripheral file for DMW96                            |"
textline " | (c) 2010 DSPG Technologies GmbH                                 |"
textline " | Version 1.0                                                     |"
textline " +-----------------------------------------------------------------+"

config 16. 8.
width  16. 8.

;=====================================================
tree "CCU      - Coherency Control Unit"
;=====================================================
;-----------------------------------------------------
tree "CCU0"
;-----------------------------------------------------
base a:0x07000000
group 0x000--0x003
 line.long 0 "CCU_CONT"
  textline ""
  hexmask.long.word 0 0.--15. 1. "    CH_EN ,"
  bitfld.long  0 16. "  SWEN  ," " 0, 1 "
  bitfld.long  0 17. " MODE  ," " 0, 1 "
  hexmask.long.byte 0 18.--21. 1. " N_CNT ,"
rgroup 0x004--0x007
 line.long 0 "CCU_STAT"
rgroup 0x008--0x00B
 line.long 0 "CCU_REQ"
wgroup 0x00C--0x00F
 hide.long 0 "CCU_SWTRIG"
group 0x010--0x013
 line.long 0 "CCU_DUMADR"
group 0x014--0x017
 line.long 0 "CCU_DUMDAT"
rgroup 0x018--0x01B
 line.long 0 "CCU_RDAT"
tree.end

;-----------------------------------------------------
tree "CCU1"
;-----------------------------------------------------
base a:0x07100000
group 0x000--0x003
 line.long 0 "CCU_CONT"
  textline ""
  hexmask.long.word 0 0.--15. 1. "    CH_EN ,"
  bitfld.long  0 16. "  SWEN  ," " 0, 1 "
  bitfld.long  0 17. " MODE  ," " 0, 1 "
  hexmask.long.byte 0 18.--21. 1. " N_CNT ,"
rgroup 0x004--0x007
 line.long 0 "CCU_STAT"
rgroup 0x008--0x00B
 line.long 0 "CCU_REQ"
wgroup 0x00C--0x00F
 hide.long 0 "CCU_SWTRIG"
group 0x010--0x013
 line.long 0 "CCU_DUMADR"
group 0x014--0x017
 line.long 0 "CCU_DUMDAT"
rgroup 0x018--0x01B
 line.long 0 "CCU_RDAT"
tree.end
tree.end

;=====================================================
tree "CIU      - Camera Interface Unit"
;=====================================================
base a:0x06700000
group 0x0000++3
 line.long 0x0 "ciu_e ,"
 textline ""
 bitfld.long 0x0 0.--0. "  ciuen ," "0,1"
 textline ""
 bitfld.long 0x0 1.--1. "  oneshoten ," "0,1"
 textline ""
 bitfld.long 0x0 2.--2. "  everynthshoten ," "0,1"
group 0x0004++3
 line.long 0x0 "ciu_intrc ,"
 textline ""
 bitfld.long 0x0 0.--0. "  intr_sclear ," "0,1"
group 0x0008++3
 line.long 0x0 "ciu_init_ctrl ,"
 textline ""
 bitfld.long 0x0 0.--0. "  timestampen ," "0,1"
 textline ""
 bitfld.long 0x0 1.--1. "  mcswen ," "0,1"
 textline ""
 bitfld.long 0x0 2.--2. "  420fcen ," "0--1"
 textline ""
 bitfld.long 0x0 3.--3. "  orgdtransfer ," "0,1"
 textline ""
 bitfld.long 0x0 4.--4. "  intren_arm ," "0,1"
 textline ""
 bitfld.long 0x0 5.--5. "  intren ," "0,1"
 textline ""
 bitfld.long 0x0 6.--6. "  reserved ," "0,1"
 textline ""
 bitfld.long 0x0 7.--7. "  fnumrst ," "0,1"
 textline ""
 bitfld.long 0x0 8.--8. "  hrsten ," "0,1"
 textline ""
 bitfld.long 0x0 9.--9. "  vrsten ," "0,1"
 textline ""
 bitfld.long 0x0 12.--12. "  syncalwaysen ," "0,1"
 textline ""
 bitfld.long 0x0 13.--13. "  statusen ," "0,1"
 textline ""
 bitfld.long 0x0 14.--14. "  scale2en ," "0,1"
 textline ""
 bitfld.long 0x0 15.--15. "  scale3en ," "0,1"
group 0x000c++3
 line.long 0x0 "ciu_ctlal ,"
 textline ""
 bitfld.long 0x0 0.--0. "  inscantype ," "0,1"
 textline ""
 bitfld.long 0x0 1.--1. "  foddexist ," "0,1"
 textline ""
 bitfld.long 0x0 2.--2. "  fieldacq ," "0,1"
 textline ""
 bitfld.long 0x0 3.--3. "  yuvfielddrop ," "0,1"
 textline ""
 bitfld.long 0x0 4.--4. "  insyncform ," "0,1"
 textline ""
 bitfld.long 0x0 5.--5. "  yuvswap ," "0,1"
 textline ""
 bitfld.long 0x0 6.--6. "  scale4en ," "0,1"
 textline ""
 bitfld.long 0x0 7.--7. "  dma2_src ," "0,1"
 textline ""
 bitfld.long 0x0 8.--8. "  dma3_src ," "0,1"
group 0x0010++3
 line.long 0x0 "ciu_ctlah ,"
 textline ""
 bitfld.long 0x0 0.--0. "  vsyncpol ," "0,1"
 textline ""
 bitfld.long 0x0 1.--1. "  hsyncpol ," "0,1"
 textline ""
 bitfld.long 0x0 2.--2. "  fsyncpol ," "0,1"
 textline ""
 bitfld.long 0x0 3.--3. "  yuvsaturation ," "0,1"
group 0x0014++3
 line.long 0x0 "ciu_ctlbl ,"
 textline ""
 bitfld.long 0x0 0.--0. "  intrarm_vmask ," "0,1"
 textline ""
 bitfld.long 0x0 1.--1. "  intrarm_hmask ," "0,1"
 textline ""
 bitfld.long 0x0 2.--2. "  intrarm_bfmask ," "0,1"
 textline ""
 bitfld.long 0x0 3.--3. "  intrarm_otmask ," "0,1"
 textline ""
 bitfld.long 0x0 4.--4. "  intrarm_ptmask ," "0,1"
 textline ""
 bitfld.long 0x0 5.--5. "  intrarm_ppmask ," "0,1"
 textline ""
 bitfld.long 0x0 6.--6. "  intrarm_txdmask ," "0,1"
 textline ""
 bitfld.long 0x0 7.--7. "  intrarm_mipimask ," "0,1"
 textline ""
 bitfld.long 0x0 8.--8. "  intrdvc_vmask ," "0,1"
 textline ""
 bitfld.long 0x0 9.--9. "  intrdvc_hmask ," "0,1"
 textline ""
 bitfld.long 0x0 10.--10. "  intrdvc_otmask ," "0,1"
 textline ""
 bitfld.long 0x0 11.--11. "  intrdvc_ptmask ," "0,1"
 textline ""
 bitfld.long 0x0 12.--12. "  intrdvc_ppmask ," "0,1"
 textline ""
 bitfld.long 0x0 13.--13. "  intrdvc_txdmask ," "0,1"
 textline ""
 bitfld.long 0x0 14.--14. "  intry_fifoerrormask ," "0,1"
 textline ""
 bitfld.long 0x0 15.--15. "  intruv_fifoerrormask ," "0,1"
 textline ""
 bitfld.long 0x0 16.--16. "  intrsy_fifoerrormask ," "0,1"
 textline ""
 bitfld.long 0x0 17.--17. "  intrsuv_fifoerrormask ," "0,1"
 textline ""
 bitfld.long 0x0 18.--18. "  intrpy_fifoerrormask ," "0,1"
 textline ""
 bitfld.long 0x0 19.--19. "  intrpuv_fifoerrormask ," "0,1"
group 0x0018++3
 line.long 0x0 "ciu_ctlbh ,"
 textline ""
 bitfld.long 0x0 0.--7.  "  intrbufflevel ," "0-127"
 textline ""
 bitfld.long 0x0 8.--13.  "  periodicfnumber ," "0-31"
group 0x001c++3
 line.long 0x0 "ciu_int1l ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  intrlinenumber ," "0-2047"
group 0x0020++3
 line.long 0x0 "ciu_int1h ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  intrperiodicline ," "0-2047"
group 0x0024++3
 line.long 0x0 "ciu_int2l ,"
 textline ""
 bitfld.long 0x0 0.--8.  "  intrhpixelpos ," "0-255"
group 0x0028++3
 line.long 0x0 "ciu_int2h ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  intrvpixelpos ," "0-2047"
group 0x002c++3
 line.long 0x0 "ciu_hsize ,"
 textline ""
 bitfld.long 0x0 0.--12.  "  fhsize ," "0-4095"
group 0x0030++3
 line.long 0x0 "ciu_vsize ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  fvsize ," "0-2047"
group 0x0034++3
 line.long 0x0 "ciu_hwindow ,"
 textline ""
 bitfld.long 0x0 0.--10.  "  whstartpos ," "0-1023"
group 0x0038++3
 line.long 0x0 "ciu_vwindow ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  wvstartpos ," "0-2047"
group 0x003c++3
 line.long 0x0 "ciu_shsize ,"
 textline ""
 bitfld.long 0x0 0.--10.  "  sfhsize ," "0-1023"
group 0x0040++3
 line.long 0x0 "ciu_svsize ,"
 textline ""
 bitfld.long 0x0 0.--9.  "  sfvsize ," "0-511"
group 0x0044++3
 line.long 0x0 "ciu_swindow ,"
 textline ""
 bitfld.long 0x0 0.--9.  "  swhstartpos ," "0-511"
 textline ""
 bitfld.long 0x0 12.--21.  "  swvstartpos ," "0-511"
group 0x0048++3
 line.long 0x0 "ciu_stata ,"
 textline ""
 bitfld.long 0x0 0.--0. "  intrsrc_vsync_arm ," "0,1"
 textline ""
 bitfld.long 0x0 1.--1. "  intrsrc_hsync_arm ," "0,1"
 textline ""
 bitfld.long 0x0 2.--2. "  intrsrc_bf_arm ," "0,1"
 textline ""
 bitfld.long 0x0 3.--3. "  intrsrc_ot_arm ," "0,1"
 textline ""
 bitfld.long 0x0 4.--4. "  intrsrc_pt_arm ," "0,1"
 textline ""
 bitfld.long 0x0 5.--5. "  intrsrc_pp_arm ," "0,1"
 textline ""
 bitfld.long 0x0 6.--6. "  intrsrc_txd_arm ," "0,1"
 textline ""
 bitfld.long 0x0 7.--7. "  intrsrc_mipi_arm ," "0,1"
 textline ""
 bitfld.long 0x0 8.--10.  "  currentimgidx ," "0-3"
 textline ""
 bitfld.long 0x0 11.--13.  "  currentpipidx ," "0-3"
 textline ""
 bitfld.long 0x0 14.--14. "  intrsrc_y_fifoerror ," "0,1"
 textline ""
 bitfld.long 0x0 15.--15. "  intrsrc_uv_fifoerror ," "0,1"
 textline ""
 bitfld.long 0x0 16.--16. "  intrsrc_sy_fifoerror ," "0,1"
 textline ""
 bitfld.long 0x0 17.--17. "  intrsrc_suv_fifoerror ," "0,1"
 textline ""
 bitfld.long 0x0 18.--18. "  intrsrc_py_fifoerror ," "0,1"
 textline ""
 bitfld.long 0x0 19.--19. "  intrsrc_puv_fifoerror ," "0,1"
group 0x004c++3
 line.long 0x0 "ciu_statbl ,"
 textline ""
 bitfld.long 0x0 0.--8.  "  y_fifo_level ," "0-255"
 textline ""
 bitfld.long 0x0 12.--18.  "  uv_fifo_level ," "0-63"
group 0x0050++3
 line.long 0x0 "ciu_statbh ,"
 textline ""
 bitfld.long 0x0 0.--7.  "  sy_fifo_level ," "0-127"
 textline ""
 bitfld.long 0x0 8.--14.  "  suv_fifo_level ," "0-63"
group 0x0054++3
 line.long 0x0 "ciu_statcl ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  current_line_num ," "0-2047"
 textline ""
 bitfld.long 0x0 12.--15.  "  current_frame_num ," "0-7"
group 0x0058++3
 line.long 0x0 "ciu_statch ,"
 textline ""
 bitfld.long 0x0 0.--15.  "  current_frame_num ," "0-32767"
group 0x005c++3
 line.long 0x0 "dma_cntl ,"
 textline ""
 bitfld.long 0x0 0.--0. "  orgimg_dma_en ," "0,1"
 textline ""
 bitfld.long 0x0 1.--1. "  scale_ydma_en ," "0,1"
 textline ""
 bitfld.long 0x0 2.--2. "  scale_uvdma_en ," "0,1"
 textline ""
 bitfld.long 0x0 3.--3. "  pip_ydma_en ," "0,1"
 textline ""
 bitfld.long 0x0 4.--4. "  pip_uvdma_en ," "0,1"
 textline ""
 bitfld.long 0x0 5.--7.  "  buff_num ," "0-3"
 textline ""
 bitfld.long 0x0 8.--13.  "  dma_burst ," "0-31"
 textline ""
 bitfld.long 0x0 14.--15.  "  swap_mode ," "0-1"
group 0x0060++3
 line.long 0x0 "dflow_ctrl ,"
 textline ""
 bitfld.long 0x0 0.--2.  "  enc_img_idx ," "0-3"
 textline ""
 bitfld.long 0x0 3.--5.  "  enc_pip_idx ," "0-3"
 textline ""
 bitfld.long 0x0 6.--6. "  ciu_img_skip ," "0,1"
 textline ""
 bitfld.long 0x0 7.--7. "  ciu_pip_skip ," "0,1"
 textline ""
 bitfld.long 0x0 8.--8. "  dflow_ctrl_src ," "0,1"
 textline ""
 bitfld.long 0x0 9.--9. "  ref_last_frame ," "0,1"
group 0x0080++3
 line.long 0x0 "ydma_addr1l ,"
group 0x0084++3
 line.long 0x0 "ydma_addr1h ,"
group 0x0088++3
 line.long 0x0 "ydma_addr2l ,"
group 0x008c++3
 line.long 0x0 "ydma_addr2h ,"
group 0x0090++3
 line.long 0x0 "ydma_ addr3l ,"
group 0x0094++3
 line.long 0x0 "ydma_addr3h ,"
group 0x0098++3
 line.long 0x0 "ydma_ addr4l ,"
group 0x009c++3
 line.long 0x0 "ydma_addr4h ,"
group 0x00a0++3
 line.long 0x0 "ydma_ addr5l ,"
group 0x00a4++3
 line.long 0x0 "ydma_addr5h ,"
group 0x00a8++3
 line.long 0x0 "ydma_ addr6l ,"
group 0x00ac++3
 line.long 0x0 "ydma_addr6h ,"
group 0x00b0++3
 line.long 0x0 "ydma_ addr7l ,"
group 0x00b4++3
 line.long 0x0 "ydma_addr7h ,"
group 0x00b8++3
 line.long 0x0 "ydma_ addr8l ,"
group 0x00bc++3
 line.long 0x0 "ydma_addr8h ,"
group 0x00c0++3
 line.long 0x0 "ydma_loffset1 ,"
group 0x00c4++3
 line.long 0x0 "ydma_loffset2 ,"
group 0x00c8++3
 line.long 0x0 "ydma_loffset3 ,"
group 0x00cc++3
 line.long 0x0 "ydma_loffset4 ,"
group 0x00d0++3
 line.long 0x0 "ydma_loffset5 ,"
group 0x00d4++3
 line.long 0x0 "ydma_loffset6 ,"
group 0x00d8++3
 line.long 0x0 "ydma_loffset7 ,"
group 0x00dc++3
 line.long 0x0 "ydma_loffset8 ,"
group 0x00e0++3
 line.long 0x0 "ydma_blk_len ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  ydma_blk_len ," "0-2047"
group 0x0100++3
 line.long 0x0 "uvdma_addr1l ,"
group 0x0104++3
 line.long 0x0 "uvdma_addr1h ,"
group 0x0108++3
 line.long 0x0 "uvdma_addr2l ,"
group 0x010c++3
 line.long 0x0 "uvdma_addr2h ,"
group 0x0110++3
 line.long 0x0 "uvdma_addr3l ,"
group 0x0114++3
 line.long 0x0 "uvdma_addr3h ,"
group 0x0118++3
 line.long 0x0 "uvdma_addr4l ,"
group 0x011c++3
 line.long 0x0 "uvdma_addr4h ,"
group 0x0120++3
 line.long 0x0 "uvdma_addr5l ,"
group 0x0124++3
 line.long 0x0 "uvdma_addr5h ,"
group 0x0128++3
 line.long 0x0 "uvdma_addr6l ,"
group 0x012c++3
 line.long 0x0 "uvdma_addr6h ,"
group 0x0130++3
 line.long 0x0 "uvdma_addr7l ,"
group 0x0134++3
 line.long 0x0 "uvdma_addr7h ,"
group 0x0138++3
 line.long 0x0 "uvdma_addr8l ,"
group 0x013c++3
 line.long 0x0 "uvdma_addr8h ,"
group 0x0140++3
 line.long 0x0 "uvdma_loffset1 ,"
group 0x0144++3
 line.long 0x0 "uvdma_loffset2 ,"
group 0x0148++3
 line.long 0x0 "uvdma_loffset3 ,"
group 0x014c++3
 line.long 0x0 "uvdma_loffset4 ,"
group 0x0150++3
 line.long 0x0 "uvdma_loffset5 ,"
group 0x0154++3
 line.long 0x0 "uvdma_loffset6 ,"
group 0x0158++3
 line.long 0x0 "uvdma_loffset7 ,"
group 0x015c++3
 line.long 0x0 "uvdma_loffset8 ,"
group 0x0160++3
 line.long 0x0 "uvdma_blk_len ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  uvdma_blk_len ," "0-2047"
group 0x0180++3
 line.long 0x0 "sydma_addr1l ,"
group 0x0184++3
 line.long 0x0 "sydma_addr1h ,"
group 0x0188++3
 line.long 0x0 "sydma_addr2l ,"
group 0x018c++3
 line.long 0x0 "sydma_addr2h ,"
group 0x0190++3
 line.long 0x0 "sydma_addr3l ,"
group 0x0194++3
 line.long 0x0 "sydma_addr3h ,"
group 0x0198++3
 line.long 0x0 "sydma_addr4l ,"
group 0x019c++3
 line.long 0x0 "sydma_addr4h ,"
group 0x01a0++3
 line.long 0x0 "sydma_loffset1 ,"
group 0x01a4++3
 line.long 0x0 "sydma_loffset2 ,"
group 0x01a8++3
 line.long 0x0 "sydma_loffset3 ,"
group 0x01ac++3
 line.long 0x0 "sydma_loffset4 ,"
group 0x01b0++3
 line.long 0x0 "sydma_blk_len ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  suvdma_blk_len ," "0-2047"
group 0x0200++3
 line.long 0x0 "suvdma_addr1l ,"
group 0x0204++3
 line.long 0x0 "suvdma_addr1h ,"
group 0x0208++3
 line.long 0x0 "suvdma_addr2l ,"
group 0x020c++3
 line.long 0x0 "suvdma_addr2h ,"
group 0x0210++3
 line.long 0x0 "suvdma_addr3l ,"
group 0x0214++3
 line.long 0x0 "suvdma_addr3h ,"
group 0x0218++3
 line.long 0x0 "suvdma_addr4l ,"
group 0x021c++3
 line.long 0x0 "suvdma_addr4h ,"
group 0x0220++3
 line.long 0x0 "suvdma_loffset1 ,"
group 0x0224++3
 line.long 0x0 "suvdma_loffset2 ,"
group 0x0228++3
 line.long 0x0 "suvdma_loffset3 ,"
group 0x022c++3
 line.long 0x0 "suvdma_loffset4 ,"
group 0x0230++3
 line.long 0x0 "suvdma_blk_len ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  suvdma_blk_len ," "0-2047"
group 0x0280++3
 line.long 0x0 "pydma_addr1l ,"
group 0x0284++3
 line.long 0x0 "pydma_addr1h ,"
group 0x0288++3
 line.long 0x0 "pydma_addr2l ,"
group 0x028c++3
 line.long 0x0 "pydma_addr2h ,"
group 0x0290++3
 line.long 0x0 "pydma_addr3l ,"
group 0x0294++3
 line.long 0x0 "pydma_addr3h ,"
group 0x0298++3
 line.long 0x0 "pydma_addr4l ,"
group 0x029c++3
 line.long 0x0 "pydma_addr4h ,"
group 0x02a0++3
 line.long 0x0 "pydma_loffset1 ,"
group 0x02a4++3
 line.long 0x0 "pydma_loffset2 ,"
group 0x02a8++3
 line.long 0x0 "pydma_loffset3 ,"
group 0x02ac++3
 line.long 0x0 "pydma_loffset4 ,"
group 0x02b0++3
 line.long 0x0 "pydma_blk_len ,"
group 0x0300++3
 line.long 0x0 "puvdma_addr1l ,"
group 0x0304++3
 line.long 0x0 "puvdma_addr1h ,"
group 0x0308++3
 line.long 0x0 "puvdma_addr2l ,"
group 0x030c++3
 line.long 0x0 "puvdma_addr2h ,"
group 0x0310++3
 line.long 0x0 "puvdma_addr3l ,"
group 0x0314++3
 line.long 0x0 "puvdma_addr3h ,"
group 0x0318++3
 line.long 0x0 "puvdma_addr4l ,"
group 0x031c++3
 line.long 0x0 "puvdma_addr4h ,"
group 0x0320++3
 line.long 0x0 "puvdma_loffset1 ,"
group 0x0324++3
 line.long 0x0 "puvdma_loffset2 ,"
group 0x0328++3
 line.long 0x0 "puvdma_loffset3 ,"
group 0x032c++3
 line.long 0x0 "puvdma_loffset4 ,"
group 0x0330++3
 line.long 0x0 "puvdma_blk_len ,"
 textline ""
 bitfld.long 0x0 0.--11.  "  puvdma_blk_len ," "0-2047"
group 0x0334++3
 line.long 0x0 "dma_arbcr ,"
 textline ""
 bitfld.long 0x0 0.--0. "  round_robin_en ," "0,1"
group 0x0340++3
 line.long 0x0 "mipi_control ,"
 textline ""
 bitfld.long 0x0 0.--0. "  yuvswap ," "0,1"
 textline ""
 bitfld.long 0x0 4.--6.  "  channel ," "0-3"
 textline ""
 bitfld.long 0x0 8.--13.  "  data_type ," "0-31"
group 0x0344++3
 line.long 0x0 "mipi_vrefcr ,"
 textline ""
 bitfld.long 0x0 0.--15.  "  vref_delay ," "0-32767"
tree.end

;=====================================================
tree "CMU      - Clock Management Unit"
;=====================================================
base a:0x05300000
group 0x000--0x003
 line.long 0 "PLL1CONTROL"
  textline ""
  hexmask.long.byte 0  0.--4.  1 "    PLL1R                 ,"
  textline ""
  hexmask.long.byte 0  5.--11. 1 "    PLL1F                 ,"
  textline ""
  bitfld.long 0 12.--13.         "    PLL1OD                ," "1,2,4,8"
  textline ""
  bitfld.long 0 14.              "    PLL1BS                ," "low band,high band"
  textline ""
  bitfld.long 0 15.              "    PLL1PD                ," "active,power-down"
  textline ""
  bitfld.long 0 16.              "    PLL1BP                ," "not bypassed,bypass mode"
  textline ""
  bitfld.long 0 17.              "    PLL1ERR               ," "legal,illegal"
  textline ""
  bitfld.long 0 18.              "    PLL1LD                ," "not locked,locked"
  textline ""
  bitfld.long 0 19.--20.         "    PLL1INSRC             ," "12MHz,20MHz,13.824MHz,Reserved"
group 0x004--0x007
 line.long 0 "PLL2CONTROL"
  textline ""
  hexmask.long.byte 0  0.--4.  1 "    PLL2R                 ,"
  textline ""
  hexmask.long.byte 0  5.--11. 1 "    PLL2F                 ,"
  textline ""
  bitfld.long 0 12.--13.         "    PLL2OD                ," "1,2,4,8"
  textline ""
  bitfld.long 0 14.              "    PLL2BS                ," "low band,high band"
  textline ""
  bitfld.long 0 15.              "    PLL2PD                ," "active,power-down"
  textline ""
  bitfld.long 0 16.              "    PLL2BP                ," "not bypassed,bypass mode"
  textline ""
  bitfld.long 0 17.              "    PLL2ERR               ," "legal,illegal"
  textline ""
  bitfld.long 0 18.              "    PLL2LD                ," "not locked,locked"
  textline ""
  bitfld.long 0 19.--20.         "    PLL2INSRC             ," "12MHz,20MHz,13.824MHz,Reserved"
group 0x008--0x00B
 line.long 0 "PLL3CONTROL"
  textline ""
  hexmask.long.byte 0  0.--4.  1 "    PLL3R                 ,"
  textline ""
  hexmask.long.byte 0  5.--11. 1 "    PLL3F                 ,"
  textline ""
  bitfld.long 0 12.--13.         "    PLL3OD                ," "1,2,4,8"
  textline ""
  bitfld.long 0 14.              "    PLL3BS                ," "low band,high band"
  textline ""
  bitfld.long 0 15.              "    PLL3PD                ," "active,power-down"
  textline ""
  bitfld.long 0 16.              "    PLL3BP                ," "not bypassed,bypass mode"
  textline ""
  bitfld.long 0 17.              "    PLL3ERR               ," "legal,illegal"
  textline ""
  bitfld.long 0 18.              "    PLL3LD                ," "not locked,locked"
  textline ""
  bitfld.long 0 19.--20.         "    PLL3INSRC             ," "12MHz,20MHz,13.824MHz,Reserved"
group 0x00C--0x00F
 line.long 0 "PLL4CONTROL"
  textline ""
  hexmask.long.byte 0  0.--4.  1 "    PLL4R                 ,"
  textline ""
  hexmask.long.byte 0  5.--11. 1 "    PLL4F                 ,"
  textline ""
  bitfld.long 0 12.--13.         "    PLL4OD                ," "1,2,4,8"
  textline ""
  bitfld.long 0 14.              "    PLL4BS                ," "low band,high band"
  textline ""
  bitfld.long 0 15.              "    PLL4PD                ," "active,power-down"
  textline ""
  bitfld.long 0 16.              "    PLL4BP                ," "not bypassed,bypass mode"
  textline ""
  bitfld.long 0 17.              "    PLL4ERR               ," "legal,illegal"
  textline ""
  bitfld.long 0 18.              "    PLL4LD                ," "not locked,locked"
  textline ""
  bitfld.long 0 19.--20.         "    PLL4INSRC             ," "12MHz,20MHz,13.824MHz,Reserved"
group 0x010--0x013
 line.long 0 "WIFIPLLCONTROL"
  textline ""
  bitfld.long 0 0.--5.     "    WPLLM                 ," "  "
  textline ""
  bitfld.long 0 6.         "    WPLLBYPASS            ," "normal,bypassed"
  textline ""
  bitfld.long 0 7.         "    WPLLCSSEL             ," "alternative,differential"
  textline ""
  bitfld.long 0 8.         "    WPLLLOCK              ," "unlocked,locked"
group 0x014--0x017
 line.long 0 "CPUCLKCNTRL"
  textline ""
  ;bitfld.long 0 0.--1.     "    CORTEXDIV             ," "1,2,3,4"
  ;textline ""
  ;bitfld.long 0 2.--3.     "    CORTEXAXI             ," "1,2,3,4"
  ;textline ""
  bitfld.long 0 4.--7.     "    SYSBUSDIV             ," "2,4,6,8,10,12,14,16,18,20,22,24,26,28,30,32"
  textline ""
  bitfld.long 0 8.--9.     "    PLL2SWCTL             ," "CPUICLK,PLL2 output,ALTSYSCLK,Reserved"
  textline ""
  bitfld.long 0 11.        "    PLL1PD_NOR            ," "PLL1 active,PLL1 power-down"
  textline ""
  bitfld.long 0 12.--13.   "    SYSSRC_NOR            ," "CPUICLK,ALTSYSSRC,PLL1,Reserved"
  textline ""
  bitfld.long 0 14.--15.   "    ALTSYSSRC             ," "12MHz,20MHz,13.824MHz,Reserved"
  textline ""
  bitfld.long 0 16.--17.   "    CPUSRC                ," "12MHz,20MHz,13.824MHz,Reserved"
  textline ""
  bitfld.long 0 18.        "    SYS_AUTO              ," "SW control,low power"
  textline ""
  bitfld.long 0 19.        "    PLL1PD_LP             ," "PLL1 active,PLL1 power-down"
  textline ""
  bitfld.long 0 20.--21.   "    SYSSRC_LP             ," "CPUICLK,ALTSYSSRC,PLL1,Reserved"
group 0x018--0x01B
 line.long 0 "COMCLKSEL"
  textline ""
  bitfld.long 0 0.--3.     "    COMALTDIV             ," "  "
  textline ""
  bitfld.long 0 4.--8.     "    COMADPCMDIV           ," "  "
  textline ""
  bitfld.long 0 9.         "    BMPREFDIV             ," "13.824MHz,13.824MHz/12"
  textline ""
  bitfld.long 0 10.--11.   "    SWCOMSRC              ," "COMALTDIV,PLL4 output,PLL4SRC,Reserved"
  textline ""
  bitfld.long 0 12.--13.   "    COMLPSRC              ," "COMALTDIV,PLL4 output,PLL4SRC,Reserved"
  textline ""
  bitfld.long 0 14.        "    COMLPEN               ," "disabled,enabled"
group 0x01C--0x01F
 line.long 0 "CLKSWCNTRL"
  textline ""
  bitfld.long 0 0.         "    SWDRAMSRC             ," "12MHz,PLL3 output"
  textline ""
  bitfld.long 0 3.         "    SLOWDIV_EN            ," "disabled,enabled" 
  textline ""
  bitfld.long 0 4.--14.    "    SLOWDIVRATE           ," "    "
  textline ""
  bitfld.long 0 15.        "    MII_CLK_SRC           ," "ETHMDIV,off-chip"
  textline ""
  bitfld.long 0 16.        "    SWSLOWSRC             ," "SLOWDIV,32kHz"
  textline ""
  bitfld.long 0 17.--18.   "    LCDDIVSRC             ," "SYSSRC,PLL3,PLL4,Reserved"
  textline ""
  bitfld.long 0 19.--20.   "    TDM1DIVSRC            ," "SYSSRC,PLL3,PLL4,Reserved"
  textline ""
  bitfld.long 0 21.--22.   "    TDM2DIVSRC            ," "SYSSRC,PLL3,PLL4,Reserved"
  textline ""
  bitfld.long 0 23.--24.   "    TDM3DIVSRC            ," "SYSSRC,PLL3,PLL4,Reserved"
  textline ""
  bitfld.long 0 25.        "    ETHRDIVSRC            ," "SYSCLK,PLL4 output"
group 0x020--0x023
 line.long 0 "CLKDIVCNTRL1"
  textline ""
  hexmask.long 0  0.--7.  1 "    CIUDIV                ,"
  textline ""
  hexmask.long 0  8.--15. 1 "    LCDPIXDIV             ,"
  textline ""
  hexmask.long 0 16.--23. 1 "    MSDIV                 ,"
  textline ""
  hexmask.long 0 24.--31. 1 "    SDDIV                 ,"
group 0x024--0x027
 line.long 0 "CLKDIVCNTRL2"
  textline ""
  hexmask.long 0  0.--3.  1 "    VIDEDIV               ,"
  textline ""
  hexmask.long 0  4.--5.  1 "    PLL4ALTSRC            ,"
  textline ""
  hexmask.long 0  8.--15. 1 "    VIDDDIV               ,"
  textline ""
  hexmask.long 0 16.--19. 1 "    GPUDIV                ,"
  textline ""
  hexmask.long 0 20.--23. 1 "    ETHRDIV               ,"
  textline ""
  hexmask.long 0 24.--31. 1 "    PLL4PREDIV            ,"
group 0x028--0x02B
 line.long 0 "CLKDIVCNTRL3"
  textline ""
  hexmask.long 0  0.--7.  1 "    DPDIV                 ,"
  textline ""
  hexmask.long 0  8.--15. 1 "    SIMDIV                ,"
group 0x02C--0x02F
 line.long 0 "CLKDIVCNTRL4"
  textline ""
  hexmask.long 0  0.--11. 1 "    TDM1DIV               ,"
  textline ""
  hexmask.long 0 12.--23. 1 "    TDM2DIV               ,"
group 0x030--0x033
 line.long 0 "CLKDIVCNTRL5"
  textline ""
  hexmask.long 0  0.--11. 1 "    TDM3DIV               ,"
  textline ""
  hexmask.long 0 12.--19. 1 "    CLKOUTDIV             ,"
group 0x034--0x037
 line.long 0 "CLKDIVCNTRL6"
  textline ""
  hexmask.long 0  0.--17. 1 "    MS_DVEN_DIV           ,"
group 0x038--0x03B
 line.long 0 "LPTMRR"
  textline ""
  hexmask.long 0  0.--15. 1 "    BREAKDISTIME          ,"
  textline ""
  hexmask.long 0 16.--19. 1 "    WIFI_PLL_DLY          ,"
  textline ""
  hexmask.long 0 20.--31. 1 "    XTALOKDURATION        ,"
group 0x03C--0x03F
 line.long 0 "CLKOSCCR"
  textline ""
  bitfld.long 0 0.         "    32K_OSC_EN            ," "disabled,enabled"
  textline ""
  bitfld.long 0 1.         "    DECT_OSC_EN           ," "disabled,enabled"
  textline ""
  bitfld.long 0 2.         "    12M_OSC_EN            ," "disabled,enabled"
  textline ""
  bitfld.long 0 3.         "    32K_OSCSTAT           ," "disabled,detected"
  textline ""
  bitfld.long 0 4.         "    DECT_OSCSTAT          ," "disabled,enabled"
  textline ""
  bitfld.long 0 5.         "    USB_OSCSTAT           ," "disabled,detected"
  textline ""
  bitfld.long 0 6.         "    WIFI_XTAL_RDY         ," "not ready,ready"
  textline ""
  hexmask.long 0 8.--11. 1 "    DECT_OSC_CTL          ,"
  textline ""
  hexmask.long 0 12.--15. 1 "    12M_OSC_CTL           ,"
wgroup 0x040--0x043
 hide.long 0 "SWSYSRST"
wgroup 0x044--0x047
 hide.long 0 "SWWRMRST"
group 0x048--0x04B
 line.long 0 "RSTSR"
  textline ""
  bitfld.long 0 2.         "    SLOWSRC_STRAP         ," "SLOWDIV,32K"
  textline ""
  bitfld.long 0 3.         "    WDRSTIND              ," "watchdog reset,no reset"
  textline ""
  bitfld.long 0 4.         "    SWWRMRSTIND           ," "software warm reset,no reset"
  textline ""
  bitfld.long 0 5.         "    SWSYSRSTIND           ," "software full reset,no reset"
  textline ""
  bitfld.long 0 6.--7.     "    CLKO_STRAP            ," "PLL2,CORTEX CPU,System bus,CLKOUTDIV"
  textline ""
  hexmask.long 0 8.--15. 1 "    UCFG                  ,"
  textline ""
  bitfld.long 0 16.        "    BOOT_SRC              ," "NOR flash,ROM"
wgroup 0x04C--0x04F
 hide.long 0 "WRPR"
sgroup
 getx a:0x05300050 %l 0
 getx a:0x05300054 %l 4
 writeback
 set a:0x0530004C %l 0x6
 setx a:0x05300050 %l 0
 set a:0x0530004C %l 0x6
 setx a:0x05300054 %l 4
 line.long 0 "SWCHWRST1"
 line.long 4 "SWCHWRST2"
  textline ""
  bitfld.long 4 20. "    CCU0_RST           " "0,1"
  bitfld.long 0  3. "    ETHMAC_RST         " "0,1"
  bitfld.long 0 13. "    SDC_RST            " "0,1"
  bitfld.long 0  7. "    UART2_RST          " "0,1"
  textline ""
  bitfld.long 4 21. "    CCU1_RST           " "0,1"
  bitfld.long 0  0. "    GDMAC_RST          " "0,1"
  bitfld.long 0  4. "    SECURE_RST         " "0,1"
  bitfld.long 0  8. "    UART3_RST          " "0,1"
  textline ""
  bitfld.long 0 19. "    CIU_RST            " "0,1"
  bitfld.long 0 24. "    GPU_RST            " "0,1"
  bitfld.long 0 22. "    SEC_RST            " "0,1"
  bitfld.long 4 23. "    USB1_MAC_PHYIF_RST " "0,1"
  textline ""
  bitfld.long 4 30. "    CORESIGHT_DBG_RST  " "0,1"
  bitfld.long 4  4. "    I2C_1_RST          " "0,1"
  bitfld.long 4  8. "    SLVMII_RST         " "0,1"
  bitfld.long 4 22. "    USB1_MAC_RST       " "0,1"
  textline ""
  bitfld.long 0 29. "    CSS_ADPCM_RST      " "0,1"
  bitfld.long 4  5. "    I2C_2_RST          " "0,1"
  bitfld.long 4 10. "    SMC_CLK_RST        " "0,1"
  bitfld.long 4 24. "    USB1_PHY_PORT_RST  " "0,1"
  textline ""
  bitfld.long 0  1. "    CSS_ARM926_RST     " "0,1"
  bitfld.long 4  9. "    IR_REMCTL_RST      " "0,1"
  bitfld.long 4  6. "    SPI1_RST           " "0,1"
  bitfld.long 4 25. "    USB1_PHY_POR_RST   " "0,1"
  textline ""
  bitfld.long 0 30. "    CSS_BMP_RST        " "0,1"
  bitfld.long 0 21. "    LCDC_RST           " "0,1"
  bitfld.long 4  7. "    SPI2_RST           " "0,1"
  bitfld.long 4 27. "    USB2_MAC_PHYIF_RST " "0,1"
  textline ""
  bitfld.long 0 31. "    CSS_ETM_RST        " "0,1"
  bitfld.long 0 12. "    MSC_RST            " "0,1"
  bitfld.long 0  9. "    TDM1_RST           " "0,1"
  bitfld.long 4 26. "    USB2_MAC_RST       " "0,1"
  textline ""
  bitfld.long 4 15. "    CSS_GDMAC_RST      " "0,1"
  bitfld.long 4 31. "    NEON_RST           " "0,1"
  bitfld.long 0 10. "    TDM2_RST           " "0,1"
  bitfld.long 4 28. "    USB2_PHY_PORT_RST  " "0,1"
  textline ""
  bitfld.long 0 23. "    CSS_RST            " "0,1"
  bitfld.long 0 14. "    NFC_RST            " "0,1"
  bitfld.long 0 11. "    TDM3_RST           " "0,1"
  bitfld.long 4 29. "    USB2_PHY_POR_RST   " "0,1"
  textline ""
  bitfld.long 4 13. "    CSS_TIMERS_RST     " "0,1"
  bitfld.long 0 20. "    OSDM_RST           " "0,1"
  bitfld.long 4  0. "    TIMER12_RST        " "0,1"
  bitfld.long 0 25. "    VIDDE_RST          " "0,1"
  textline ""
  bitfld.long 4 18. "    DBM_RST            " "0,1"
  bitfld.long 0 15. "    PACP_RST           " "0,1"
  bitfld.long 4  1. "    TIMER34_RST        " "0,1"
  bitfld.long 0 26. "    VIDEN_RST          " "0,1"
  textline ""
  bitfld.long 4 12. "    DRAM_CTL_RST       " "0,1"
  bitfld.long 0  2. "    RTC_RST            " "0,1"
  bitfld.long 0  6. "    UART1_RST          " "0,1"
  bitfld.long 0 18. "    WIFI_RST           " "0,1"
sgroup
 getx a:0x05300058 %l 0
 getx a:0x0530005C %l 4
 writeback
 set a:0x0530004C %l 0x90
 setx a:0x05300058 %l 0
 set a:0x0530004C %l 0x90
 setx a:0x0530005C %l 4
 line.long 0 "SWCLKENR1"
 line.long 4 "SWCLKENR2"
  textline ""
  bitfld.long 0 15. "    ACP_CLK_EN         ," "0,1"
  bitfld.long 4 12. "    DRAM_CTL_CLK_EN    ," "0,1"
  bitfld.long 0  2. "    RTC_CLK_EN         ," "0,1"
  bitfld.long 4  1. "    TIMER2_CLK_EN      ," "0,1"
  textline ""
  bitfld.long 0 19. "    CIU_CLK_EN         ," "0,1"
  bitfld.long 0  3. "    ETHMAC_CLK_EN      ," "0,1"
  bitfld.long 0 13. "    SDC_CLK_EN         ," "0,1"
  bitfld.long 4  2. "    TIMER3_CLK_EN      ," "0,1"
  textline ""
  bitfld.long 4 11. "    CLKOUT_CLK_EN      ," "0,1"
  bitfld.long 0  0. "    GDMAC_CLK_EN       ," "0,1"
  bitfld.long 0  4. "    SECURE_CLK_EN      ," "0,1"
  bitfld.long 4  3. "    TIMER4_CLK_EN      ," "0,1"
  textline ""
  bitfld.long 4 20. "    CORESIGHT_CLK_EN   ," "0,1"
  bitfld.long 0 24. "    GPU_CLK_EN         ," "0,1"
  bitfld.long 0 22. "    SEC_CLK_EN         ," "0,1"
  bitfld.long 0  6. "    UART1_CLK_EN       ," "0,1"
  textline ""
  bitfld.long 0 29. "    CSS_ADPCM_CLK_EN   ," "0,1"
  bitfld.long 4  4. "    I2C_1_CLK_EN       ," "0,1"
  bitfld.long 0 27. "    SIM_CLK_EN         ," "0,1"
  bitfld.long 0  7. "    UART2_CLK_EN       ," "0,1"
  textline ""
  bitfld.long 0  1. "    CSS_ARM926_CLK_EN  ," "0,1"
  bitfld.long 4  5. "    I2C_2_CLK_EN       ," "0,1"
  bitfld.long 4  8. "    SLVMII_CLK_EN      ," "0,1"
  bitfld.long 0  8. "    UART3_CLK_EN       ," "0,1"
  textline ""
  bitfld.long 0 30. "    CSS_BMP_CLK_EN     ," "0,1"
  bitfld.long 4  9. "    IR_REMCTL_CLK_EN   ," "0,1"
  bitfld.long 4 10. "    SMC_CLK_EN         ," "0,1"
  bitfld.long 4 16. "    USB2_MAC_CLK_EN    ," "0,1"
  textline ""
  bitfld.long 0 23. "    CSS_CLK_EN         ," "0,1"
  bitfld.long 0 21. "    LCDC_CLK_EN        ," "0,1"
  bitfld.long 4  6. "    SPI1_CLK_EN        ," "0,1"
  bitfld.long 4 17. "    USB2_PHY_CLK_EN    ," "0,1"
  textline ""
  bitfld.long 0 31. "    CSS_ETM_CLK_EN     ," "0,1"
  bitfld.long 0 12. "    MSC_CLK_EN         ," "0,1"
  bitfld.long 4  7. "    SPI2_CLK_EN        ," "0,1"
  bitfld.long 0 16. "    USB_MAC_CLK_EN     ," "0,1"
  textline ""
  bitfld.long 4 15. "    CSS_GDMAC_CLK_EN   ," "0,1"
  bitfld.long 0 14. "    NFC_CLK_EN         ," "0,1"
  bitfld.long 0  9. "    TDM1_CLK_EN        ," "0,1"
  bitfld.long 0 17. "    USB_PHY_CLK_EN     ," "0,1"
  textline ""
  bitfld.long 4 13. "    CSS_TIMER1_CLK_EN  ," "0,1"
  bitfld.long 0 20. "    OSDM_CLK_EN        ," "0,1"
  bitfld.long 0 10. "    TDM2_CLK_EN        ," "0,1"
  bitfld.long 0 25. "    VIDDE_CLK_EN       ," "0,1"
  textline ""
  bitfld.long 4 14. "    CSS_TIMER2_CLK_EN  ," "0,1"
  bitfld.long 4 19. "    PLL4PREDIV_EN      ," "0,1"
  bitfld.long 0 11. "    TDM3_CLK_EN        ," "0,1"
  bitfld.long 0 26. "    VIDEN_CLK_EN       ," "0,1"
  textline ""
  bitfld.long 4 18. "    DBM_CLK_EN         ," "0,1"
  bitfld.long 0  5. "    RMII_IF_CLK_EN     ," "0,1"
  bitfld.long 4  0. "    TIMER1_CLK_EN      ," "0,1"
  bitfld.long 0 18. "    WIFI_CLK_EN        ," "0,1"
  textline ""
  bitfld.long 0 28. "    DP_CLK_EN          ," "0,1"
rgroup 0x060--0x063
 line.long 0 "CUSTATR"
  textline ""
  bitfld.long 0  0.        "    OSC12M_IN_USE         ," "0,1"
  textline ""
  bitfld.long 0  1.        "    OSC13M_IN_USE         ," "0,1"
  textline ""
  bitfld.long 0  2.        "    CLK20M_IN_USE         ," "0,1"
  textline ""
  bitfld.long 0  3.        "    OSC32K_IN_USE         ," "0,1"
  textline ""
  bitfld.long 0  4.        "    PLL1_IN_USE           ," "0,1"
  textline ""
  bitfld.long 0  5.        "    PLL2_IN_USE           ," "0,1"
  textline ""
  bitfld.long 0  6.        "    PLL3_IN_USE           ," "0,1"
  textline ""
  bitfld.long 0  7.        "    PLL4_IN_USE           ," "0,1"
  textline ""
  bitfld.long 0  8.        "    SYS_SRC_0_IN_USE      ," "0,1"
  textline ""
  bitfld.long 0  9.        "    SYS_SRC_1_IN_USE      ," "0,1"
  textline ""
  bitfld.long 0 10.        "    SYS_SRC_2_IN_USE      ," "0,1"
  textline ""
  bitfld.long 0 11.        "    CPUSRC_IN_USE         ," "0,1"
  textline ""
  bitfld.long 0 12.        "    COM_ALT_IN_USE        ," "0,1"
  textline ""
  bitfld.long 0 13.        "    PLL4SRC_IN_USE        ," "0,1"
  textline ""
  bitfld.long 0 14.        "    DIVSCSLK_IN_USE       ," "0,1"
  textline ""
  bitfld.long 0 15.        "    ALTSYSSRC_IN_USE      ," "0,1"
group 0x064--0x067
 line.long 0 "SWOVRCTL"
  textline ""
  bitfld.long 0 0.         "    SW_OVR_SEL            ," "0,1"
  textline ""
  bitfld.long 0 1.         "    SW_OVR_CTL            ," "0,1"
  textline ""
  bitfld.long 0 2.         "    SW_SYS_20M_OVR_CTL    ," "0,1"
  textline ""
  bitfld.long 0 3.         "    SW_WIFI_OVR_SEL       ," "0,1"
  textline ""
  bitfld.long 0 4.         "    SW_WIFI_OVR_CTL       ," "0,1"
  textline ""
  bitfld.long 0 5.--7.     "    WIFI_FSM_STATE        ," "off,WIFI_PLL_DELAY,ready,XTALON_DELAY,breaking distance,-,-,-"
  textline ""
  bitfld.long 0 8.         "    HW_REQ_20M_STS        ," "0,1"
  textline ""
  bitfld.long 0 9.--10.    "    SWCOMSRC_SEL          ," "COMALTDIV,PLL4 output,PLL4SRC,Reserved"
  textline ""
  bitfld.long 0 11.--12.   "    SYSSRC_SEL            ," "CPISCLK,ALTSYSCLK,PLL1 output,Reserved"
  textline ""
  bitfld.long 0 13.        "    PD_FSM_STATE          ," "PLL1 powered down,PLL1 enabled"
  textline ""
  bitfld.long 0 14.--16.   "    SYS_FSM_STATE         ," "-,CPUICLK,-,ALTSYSCLK,-,PLL1,-,-"
  textline ""
  bitfld.long 0 17.        "    CLK20M_EN             ," "disabled,enabled"
group 0x068--0x06B
 line.long 0 "CMU_TEST"
  textline ""
  bitfld.long 0 0.--4. "    CLOCK_OUT_SEL         ," "sysclk,tdm3div,tdm2div,tdm1div,lcdpixdiv,gpudiv,msdiv,sddiv,sysbusdiv,dpdiv,comaltdiv,videncdiv,viddecdiv,simdiv,ethrdiv,slowdiv,dram_2occ,com_arm,20m,com_adpcm,com_bmp,ciudiv,ethrintdiv,32k_osc,13m_osc,80m_pll5,12m_osc,usb1otg_phy,usb2otg_phy,slow,gpudiv_out_div2,cc_rnd_src"
  textline ""
  bitfld.long 0 8.         "    13M_BP_DIV_4_EN       ," "0,1"
  textline ""
  bitfld.long 0 9.         "    PLL4_BP_DIV_4_EN      ," "0,1"
  textline ""
  bitfld.long 0 10.        "    SYSFSM_BP             ," "0,1"
  textline ""
  bitfld.long 0 11.        "    HW_REQ_20M_CFG        ," "0,1"
  textline ""
  bitfld.long 0 12.        "    ARM_CLK_EN_BP         ," "0,1"
  textline ""
  bitfld.long 0 16.        "    ARM_MCLK_EN           ," "0,1"
  textline ""
  bitfld.long 0 17.        "    ARM_STANDBY_WFI       ," "0,1"
  textline ""
  bitfld.long 0 18.        "    CORTEX_STANDBY_WFI    ," "0,1"
  textline ""
  bitfld.long 0 19.        "    SW500MSRC_CLK2_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 20.        "    SW500MSRC_CLK1_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 21.        "    SW500MSRC_CLK0_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 22.        "    SWSLOWSRC_CLK1_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 23.        "    SWSLOWSRC_CLK0_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 24.        "    SWDRAMSRC_CLK1_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 25.        "    SWDRAMSRC_CLK0_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 26.        "    SWCOMSRC_CLK2_IN_USE  ," "0,1"
  textline ""
  bitfld.long 0 27.        "    SWCOMSRC_CLK1_IN_USE  ," "0,1"
  textline ""
  bitfld.long 0 28.        "    SWCOMSRC_CLK0_IN_USE  ," "0,1"
  textline ""
  bitfld.long 0 29.        "    PLL2SW_CLK2_IN_USE    ," "0,1"
  textline ""
  bitfld.long 0 30.        "    PLL2SW_CLK1_IN_USE    ," "0,1"
  textline ""
  bitfld.long 0 31.        "    PLL2SW_CLK0_IN_USE    ," "0,1"
tree.end

;=====================================================
tree "DRAM     - Denali DRAM controller"
;=====================================================
base a:0x00100000
group 0x000--0x1FF
  textline ""
  hexmask.long.byte 212. 24.--28. 1 "add_odt_clk_difftype_diffcs     "
  textline ""
  bitfld.long 212. 8.--11. "add_odt_clk_r2w_samecs          " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 216. 0.--3. "add_odt_clk_sametype_diffcs     " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 212. 16.--19. "add_odt_clk_w2r_samecs          " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 168. 8.--8. "addr_cmp_en                     " "0,1"
  textline ""
  bitfld.long 152. 0.--2. "addr_pins_0                     " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 152. 8.--10. "addr_pins_1                     " "0,1,2,3,4,5,6,7"
  textline ""
  hexmask.long.byte 164. 24.--30. 1 "age_count                       "
  textline ""
  bitfld.long 228. 16.--19. "ahb0_rdlen                      " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 232. 0.--3. "ahb1_rdlen                      " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 232. 16.--19. "ahb2_rdlen                      " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 236. 0.--3. "ahb3_rdlen                      " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 228. 8.--11. "ahb0_wrlen                      " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 228. 24.--27. "ahb1_wrlen                      " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 232. 8.--11. "ahb2_wrlen                      " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 232. 24.--27. "ahb3_wrlen                      " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 40. 16.--16. "ap                              " "0,1"
  textline ""
  bitfld.long 156. 0.--3. "aprebit_0                       " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 156. 8.--11. "aprebit_1                       " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 308. 24.--27. "arb_cmd_q_threshold             " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 56. 24.--24. "arefresh                        " "0,1"
  textline ""
  bitfld.long 60. 0.--0. "auto_refresh_mode               " "0,1"
  textline ""
  hexmask.long.byte 104. 16.--23. 1 "auto_tempchk_val                "
  textline ""
  hexmask.long.byte 312. 0.--6. 1 "axi0_bdw                        "
  textline ""
  hexmask.long.byte 312. 24.--30. 1 "axi1_bdw                        "
  textline ""
  hexmask.long.byte 316. 16.--22. 1 "axi2_bdw                        "
  textline ""
  hexmask.long.byte 320. 8.--14. 1 "axi3_bdw                        "
  textline ""
  hexmask.long.byte 324. 0.--6. 1 "axi4_bdw                        "
  textline ""
  hexmask.long.byte 324. 24.--30. 1 "axi5_bdw                        "
  textline ""
  hexmask.long.byte 328. 16.--22. 1 "axi6_bdw                        "
  textline ""
  hexmask.long.byte 332. 8.--14. 1 "axi7_bdw                        "
  textline ""
  bitfld.long 312. 8.--8. "axi0_bdw_ovflow                 " "0,1"
  textline ""
  bitfld.long 316. 0.--0. "axi1_bdw_ovflow                 " "0,1"
  textline ""
  bitfld.long 316. 24.--24. "axi2_bdw_ovflow                 " "0,1"
  textline ""
  bitfld.long 320. 16.--16. "axi3_bdw_ovflow                 " "0,1"
  textline ""
  bitfld.long 324. 8.--8. "axi4_bdw_ovflow                 " "0,1"
  textline ""
  bitfld.long 328. 0.--0. "axi5_bdw_ovflow                 " "0,1"
  textline ""
  bitfld.long 328. 24.--24. "axi6_bdw_ovflow                 " "0,1"
  textline ""
  bitfld.long 332. 16.--16. "axi7_bdw_ovflow                 " "0,1"
  textline ""
  hexmask.long.byte 312. 16.--22. 1 "axi0_current_bdw                "
  textline ""
  hexmask.long.byte 316. 8.--14. 1 "axi1_current_bdw                "
  textline ""
  hexmask.long.byte 320. 0.--6. 1 "axi2_current_bdw                "
  textline ""
  hexmask.long.byte 320. 24.--30. 1 "axi3_current_bdw                "
  textline ""
  hexmask.long.byte 324. 16.--22. 1 "axi4_current_bdw                "
  textline ""
  hexmask.long.byte 328. 8.--14. 1 "axi5_current_bdw                "
  textline ""
  hexmask.long.byte 332. 0.--6. 1 "axi6_current_bdw                "
  textline ""
  hexmask.long.byte 332. 24.--30. 1 "axi7_current_bdw                "
  textline ""
  hexmask.long.word 236. 8.--23. 1 "axi0_en_size_lt_width_instr     "
  textline ""
  hexmask.long.word 240. 8.--23. 1 "axi1_en_size_lt_width_instr     "
  textline ""
  hexmask.long.word 244. 8.--23. 1 "axi2_en_size_lt_width_instr     "
  textline ""
  hexmask.long.word 248. 8.--23. 1 "axi3_en_size_lt_width_instr     "
  textline ""
  hexmask.long.word 252. 8.--23. 1 "axi4_en_size_lt_width_instr     "
  textline ""
  hexmask.long.word 256. 8.--23. 1 "axi5_en_size_lt_width_instr     "
  textline ""
  hexmask.long.word 260. 8.--23. 1 "axi6_en_size_lt_width_instr     "
  textline ""
  hexmask.long.word 264. 8.--23. 1 "axi7_en_size_lt_width_instr     "
  textline ""
  bitfld.long 236. 24.--26. "axi0_r_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 240. 24.--26. "axi1_r_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 244. 24.--26. "axi2_r_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 248. 24.--26. "axi3_r_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 252. 24.--26. "axi4_r_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 256. 24.--26. "axi5_r_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 260. 24.--26. "axi6_r_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 264. 24.--26. "axi7_r_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 240. 0.--2. "axi0_w_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 244. 0.--2. "axi1_w_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 248. 0.--2. "axi2_w_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 252. 0.--2. "axi3_w_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 256. 0.--2. "axi4_w_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 260. 0.--2. "axi5_w_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 264. 0.--2. "axi6_w_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 268. 0.--2. "axi7_w_priority                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 168. 16.--16. "bank_split_en                   " "0,1"
  textline ""
  bitfld.long 52. 0.--2. "bstlen                          " "0,1,2,3,4,5,6,7"
  textline ""
  hexmask.long.byte 24. 8.--12. 1 "caslat_lin                      "
  textline ""
  bitfld.long 80. 0.--2. "cke_delay                       " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 336. 8.--8. "cke_status                      " "0,1"
  textline ""
  bitfld.long 92. 0.--3. "cksre                           " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 92. 8.--11. "cksrx                           " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 152. 16.--18. "column_size_0                   " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 152. 24.--26. "column_size_1                   " "0,1,2,3,4,5,6,7"
  textline ""
  hexmask.long.byte 168. 0.--6. 1 "command_age_count               "
  textline ""
  bitfld.long 40. 24.--24. "concurrentap                    " "0,1"
  textline ""
  bitfld.long 164. 16.--16. "config_error                    " "0,1"
  textline ""
  bitfld.long 176. 8.--9. "cs_map                          " "0,1,2,3"
  textline ""
  hexmask.long.word 160. 16.--31. 1 "cs_msk_0                        "
  textline ""
  hexmask.long.word 164. 0.--15. 1 "cs_msk_1                        "
  textline ""
  hexmask.long.word 156. 16.--31. 1 "cs_val_0                        "
  textline ""
  hexmask.long.word 160. 0.--15. 1 "cs_val_1                        "
  textline ""
  hexmask.long.byte 340. 0.--7. 1 "dll_rst_adj_dly                 "
  textline ""
  hexmask.long.word 336. 16.--31. 1 "dll_rst_delay                   "
  textline ""
  bitfld.long 0. 8.--11. "dram_class                      " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 344. 16.--17. "dram_clk_disable                " "0,1,2,3"
  textline ""
  bitfld.long 336. 0.--0. "drive_dq_dqs                    " "0,1"
  textline ""
  bitfld.long 148. 16.--16. "eight_bank_mode_0               " "0,1"
  textline ""
  bitfld.long 148. 24.--24. "eight_bank_mode_1               " "0,1"
  textline ""
  bitfld.long 76. 24.--24. "enable_quick_srefresh           " "0,1"
  textline ""
  bitfld.long 180. 0.--0. "fast_write                      " "0,1"
  textline ""
  bitfld.long 176. 0.--1. "inhibit_dram_cmd                " "0,1,2,3"
  textline ""
  bitfld.long 24. 0.--3. "initaref                        " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  hexmask.long.word 184. 16.--29. 1 "int_ack                         "
  textline ""
  hexmask.long.word 188. 0.--14. 1 "int_mask                        "
  textline ""
  hexmask.long.word 184. 0.--14. 1 "int_status                      "
  textline ""
  hexmask.long.byte 88. 0.--4. 1 "lowpower_auto_enable            "
  textline ""
  hexmask.long.byte 80. 8.--12. 1 "lowpower_control                "
  textline ""
  hexmask.long.word 84. 16.--31. 1 "lowpower_external_cnt           "
  textline ""
  hexmask.long.word 88. 8.--23. 1 "lowpower_internal_cnt           "
  textline ""
  hexmask.long.word 80. 16.--31. 1 "lowpower_power_down_cnt         "
  textline ""
  bitfld.long 88. 24.--25. "lowpower_refresh_enable         " "0,1,2,3"
  textline ""
  hexmask.long.word 84. 0.--15. 1 "lowpower_self_refresh_cnt       "
  textline ""
  bitfld.long 176. 24.--24. "lpddr2_s4                       " "0,1"
  textline ""
  bitfld.long 4. 8.--11. "max_col_reg                     " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 4. 16.--17. "max_cs_reg                      " "0,1,2,3"
  textline ""
  bitfld.long 4. 0.--3. "max_row_reg                     " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  hexmask.long.word 108. 0.--14. 1 "mr0_data_0                      "
  textline ""
  hexmask.long.word 120. 8.--22. 1 "mr0_data_1                      "
  textline ""
  hexmask.long.word 108. 16.--30. 1 "mr1_data_0                      "
  textline ""
  hexmask.long.word 124. 0.--14. 1 "mr1_data_1                      "
  textline ""
  hexmask.long.word 112. 0.--14. 1 "mr2_data_0                      "
  textline ""
  hexmask.long.word 124. 16.--30. 1 "mr2_data_1                      "
  textline ""
  hexmask.long.word 116. 0.--14. 1 "mr3_data_0                      "
  textline ""
  hexmask.long.word 128. 16.--30. 1 "mr3_data_1                      "
  textline ""
  hexmask.long.byte 116. 16.--23. 1 "mr8_data_0                      "
  textline ""
  hexmask.long.byte 132. 0.--7. 1 "mr8_data_1                      "
  textline ""
  hexmask.long.byte 116. 24.--31. 1 "mr16_data_0                     "
  textline ""
  hexmask.long.byte 132. 8.--15. 1 "mr16_data_1                     "
  textline ""
  hexmask.long.byte 120. 0.--7. 1 "mr17_data_0                     "
  textline ""
  hexmask.long.byte 132. 16.--23. 1 "mr17_data_1                     "
  textline ""
  hexmask.long.word 112. 16.--30. 1 "mrsingle_data_0                 "
  textline ""
  hexmask.long.word 128. 0.--14. 1 "mrsingle_data_1                 "
  textline ""
  hexmask.long.byte 100. 0.--7. 1 "mrw_status                      "
  textline ""
  bitfld.long 20. 24.--24. "no_auto_mrr_init                " "0,1"
  textline ""
  bitfld.long 48. 16.--16. "no_cmd_init                     " "0,1"
  textline ""
  bitfld.long 148. 0.--0. "no_zq_init                      " "0,1"
  textline ""
  hexmask.long.byte 224. 24.--28. 1 "ocd_adjust_pdn_cs_0             "
  textline ""
  hexmask.long.byte 228. 0.--4. 1 "ocd_adjust_pup_cs_0             "
  textline ""
  bitfld.long 364. 8.--8. "odt_alt_en                      " "0,1"
  textline ""
  bitfld.long 208. 8.--9. "odt_rd_map_cs0                  " "0,1,2,3"
  textline ""
  bitfld.long 208. 24.--25. "odt_rd_map_cs1                  " "0,1,2,3"
  textline ""
  bitfld.long 208. 16.--17. "odt_wr_map_cs0                  " "0,1,2,3"
  textline ""
  bitfld.long 212. 0.--1. "odt_wr_map_cs1                  " "0,1,2,3"
  textline ""
  hexmask.long 192. 0.--31. 1 "out_of_range_addr               "
  textline ""
  hexmask.long.byte 196. 8.--14. 1 "out_of_range_length             "
  textline ""
  hexmask.long.byte 196. 24.--31. 1 "out_of_range_source_id          "
  textline ""
  hexmask.long.byte 196. 16.--21. 1 "out_of_range_type               "
  textline ""
  hexmask.long.word 104. 0.--15. 1 "peripheral_mrr_data             "
  textline ""
  bitfld.long 168. 24.--24. "placement_en                    " "0,1"
  textline ""
  hexmask.long 200. 0.--31. 1 "port_cmd_error_addr             "
  textline ""
  hexmask.long.byte 204. 8.--15. 1 "port_cmd_error_id               "
  textline ""
  bitfld.long 204. 16.--19. "port_cmd_error_type             " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  hexmask.long.byte 204. 24.--31. 1 "port_data_error_id              "
  textline ""
  bitfld.long 208. 0.--2. "port_data_error_type            " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 68. 0.--0. "power_down                      " "0,1"
  textline ""
  bitfld.long 172. 0.--0. "priority_en                     " "0,1"
  textline ""
  bitfld.long 76. 8.--8. "pwrup_srefresh_exit             " "0,1"
  textline ""
  bitfld.long 180. 8.--11. "q_fullness                      " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 216. 8.--10. "r2r_diffcs_dly                  " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 220. 8.--10. "r2r_samecs_dly                  " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 216. 16.--18. "r2w_diffcs_dly                  " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 220. 16.--18. "r2w_samecs_dly                  " "0,1,2,3,4,5,6,7"
  textline ""
  hexmask.long.byte 360. 5.--9. 1 "rdlat_adj                       "
  textline ""
  hexmask.long 100. 8.--24. 1 "read_modereg                    "
  textline ""
  bitfld.long 176. 16.--16. "reduc                           " "0,1"
  textline ""
  hexmask.long.byte 104. 24.--31. 1 "refresh_per_auto_tempchk        "
  textline ""
  hexmask.long.byte 140. 24.--31. 1 "refresh_per_zq                  "
  textline ""
  bitfld.long 56. 16.--16. "reg_dimm_enable                 " "0,1"
  textline ""
  bitfld.long 180. 16.--16. "resync_dll                      " "0,1"
  textline ""
  bitfld.long 180. 24.--24. "resync_dll_per_aref_en          " "0,1"
  textline ""
  bitfld.long 172. 8.--8. "rw_same_en                      " "0,1"
  textline ""
  bitfld.long 76. 0.--0. "srefresh                        " "0,1"
  textline ""
  bitfld.long 76. 16.--16. "srefresh_exit_no_refresh        " "0,1"
  textline ""
  bitfld.long 0. 0.--0. "start                           " "0,1"
  textline ""
  bitfld.long 172. 16.--16. "swap_en                         " "0,1"
  textline ""
  bitfld.long 172. 24.--24. "swap_port_rw_same_en            " "0,1"
  textline ""
  bitfld.long 24. 24.--26. "tbst_int_interval               " "0,1,2,3,4,5,6,7"
  textline ""
  hexmask.long.byte 28. 0.--4. 1 "tccd                            "
  textline ""
  bitfld.long 36. 24.--26. "tcke                            " "0,1,2,3,4,5,6,7"
  textline ""
  hexmask.long.byte 40. 0.--4. 1 "tckesr                          "
  textline ""
  hexmask.long.word 52. 16.--31. 1 "tcpd                            "
  textline ""
  hexmask.long.byte 44. 24.--28. 1 "tdal                            "
  textline ""
  bitfld.long 360. 16.--19. "tdfi_ctrl_delay                 " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  hexmask.long.word 348. 0.--15. 1 "tdfi_ctrlupd_max                "
  textline ""
  bitfld.long 344. 24.--27. "tdfi_ctrlupd_min                " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 360. 24.--26. "tdfi_dram_clk_disable           " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 364. 0.--3. "tdfi_dram_clk_enable            " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  hexmask.long.byte 340. 24.--28. 1 "tdfi_phy_rdlat                  "
  textline ""
  bitfld.long 340. 8.--11. "tdfi_phy_wrlat                  " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 340. 16.--19. "tdfi_phy_wrlat_base             " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  hexmask.long.word 356. 16.--31. 1 "tdfi_phyupd_resp                "
  textline ""
  hexmask.long.word 348. 16.--31. 1 "tdfi_phyupd_type0               "
  textline ""
  hexmask.long.word 352. 0.--15. 1 "tdfi_phyupd_type1               "
  textline ""
  hexmask.long.word 352. 16.--31. 1 "tdfi_phyupd_type2               "
  textline ""
  hexmask.long.word 356. 0.--15. 1 "tdfi_phyupd_type3               "
  textline ""
  hexmask.long.byte 344. 0.--4. 1 "tdfi_rddata_en                  "
  textline ""
  hexmask.long.byte 344. 8.--12. 1 "tdfi_rddata_en_base             "
  textline ""
  hexmask.long.word 48. 0.--15. 1 "tdll                            "
  textline ""
  bitfld.long 224. 8.--9. "tdqsck_max                      " "0,1,2,3"
  textline ""
  bitfld.long 224. 16.--17. "tdqsck_min                      " "0,1,2,3"
  textline ""
  hexmask.long.byte 52. 8.--13. 1 "tfaw                            "
  textline ""
  hexmask.long 8. 0.--23. 1 "tinit                           "
  textline ""
  hexmask.long 12. 0.--23. 1 "tinit3                          "
  textline ""
  hexmask.long 16. 0.--23. 1 "tinit4                          "
  textline ""
  hexmask.long 20. 0.--23. 1 "tinit5                          "
  textline ""
  hexmask.long.byte 36. 0.--7. 1 "tmod                            "
  textline ""
  hexmask.long.byte 32. 24.--28. 1 "tmrd                            "
  textline ""
  bitfld.long 48. 24.--27. "tmrr                            " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  hexmask.long.word 68. 8.--23. 1 "tpdex                           "
  textline ""
  bitfld.long 44. 0.--0. "tras_lockout                    " "0,1"
  textline ""
  hexmask.long.word 36. 8.--23. 1 "tras_max                        "
  textline ""
  hexmask.long.byte 28. 24.--31. 1 "tras_min                        "
  textline ""
  hexmask.long.byte 28. 16.--23. 1 "trc                             "
  textline ""
  hexmask.long.byte 44. 8.--15. 1 "trcd_int                        "
  textline ""
  hexmask.long.word 64. 0.--15. 1 "tref                            "
  textline ""
  bitfld.long 60. 8.--8. "tref_enable                     " "0,1"
  textline ""
  hexmask.long.word 64. 16.--29. 1 "tref_interval                   "
  textline ""
  hexmask.long.word 60. 16.--25. 1 "trfc                            "
  textline ""
  hexmask.long.byte 32. 8.--12. 1 "trp                             "
  textline ""
  hexmask.long.byte 56. 0.--4. 1 "trp_ab_0                        "
  textline ""
  hexmask.long.byte 56. 8.--12. 1 "trp_ab_1                        "
  textline ""
  hexmask.long.byte 28. 8.--15. 1 "trrd                            "
  textline ""
  bitfld.long 32. 16.--18. "trtp                            " "0,1,2,3,4,5,6,7"
  textline ""
  hexmask.long.byte 44. 16.--20. 1 "twr_int                         "
  textline ""
  bitfld.long 32. 0.--3. "twtr                            " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  hexmask.long.word 72. 16.--31. 1 "txsnr                           "
  textline ""
  hexmask.long.word 72. 0.--15. 1 "txsr                            "
  textline ""
  hexmask.long.word 0. 16.--31. 1 "version                         "
  textline ""
  bitfld.long 216. 24.--26. "w2r_diffcs_dly                  " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 220. 24.--26. "w2r_samecs_dly                  " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 220. 0.--2. "w2w_diffcs_dly                  " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long 224. 0.--2. "w2w_samecs_dly                  " "0,1,2,3,4,5,6,7"
  textline ""
  hexmask.long 96. 0.--25. 1 "write_modereg                   "
  textline ""
  bitfld.long 40. 8.--8. "writeinterp                     " "0,1"
  textline ""
  bitfld.long 24. 16.--19. "wrlat                           " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 360. 4.--7. "wrlat_adj                       " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 308. 16.--17. "wrtprct_enable                  " "0,1,2,3"
  textline ""
  hexmask.long 304. 0.--31. 1 "wrtprct_error_address           "
  textline ""
  hexmask.long.byte 308. 8.--14. 1 "wrtprct_error_length            "
  textline ""
  hexmask.long 280. 0.--31. 1 "wrtprct_lower_address_0         "
  textline ""
  hexmask.long 296. 0.--31. 1 "wrtprct_lower_address_1         "
  textline ""
  hexmask.long 272. 0.--31. 1 "wrtprct_upper_address_0         "
  textline ""
  hexmask.long 288. 0.--31. 1 "wrtprct_upper_address_1         "
  textline ""
  bitfld.long 144. 8.--8. "zq_in_progress                  " "0,1"
  textline ""
  bitfld.long 144. 0.--3. "zq_on_sref_exit                 " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 140. 16.--19. "zq_req                          " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  hexmask.long.word 136. 16.--27. 1 "zqcl                            "
  textline ""
  hexmask.long.word 140. 0.--11. 1 "zqcs                            "
  textline ""
  bitfld.long 148. 8.--8. "zqcs_rotate                     " "0,1"
  textline ""
  hexmask.long.word 136. 0.--11. 1 "zqinit                          "
  textline ""
  hexmask.long.word 144. 16.--27. 1 "zqreset                         "
  textline ""
tree.end

;=====================================================
tree "DWC      - SD/MMC"
;=====================================================
base a:0x00900000
group 0x000--0x003
 line.long 0 "CTRL"
  bitfld.long 0 25. ": use_internal_dmac " "0,1"
  bitfld.long 0  8. "  abort_read_data " "0,1"
  bitfld.long 0  4. "  int_enable ,Global interrupt enable/disable" "0,1"
  textline "                         "
  bitfld.long 0  2. "  dma_reset         " "0,1"
  bitfld.long 0  1. "  fifo_reset " "0,1"
  bitfld.long 0  0. "  controller_reset " "0,1"
group 0x004--0x007
 line.long 0 "PWREN"
group 0x008--0x00B
 line.long 0 "CLKDIV"
group 0x00C--0x00F
 line.long 0 "CLKSRC"
group 0x010--0x013
 line.long 0 "CLKENA"
group 0x014--0x017
 line.long 0 "TMOUT"
group 0x018--0x01B
 line.long 0 "CTYPE"
group 0x01C--0x01F
 line.long 0 "BLKSIZ"
group 0x020--0x023
 line.long 0 "BYTCNT"
group 0x024--0x027
 line.long 0 "INTMASK"
group 0x028--0x02B
 line.long 0 "CMDARG"
group 0x02C--0x02F
 line.long 0 "CMD"
  bitfld.long 0 31. ": ,Start command" "-,--START COMMAND--"
  textline "                         "
  bitfld.long 0 29. "  use_hold_reg                " "0,1"
  bitfld.long 0 28. "  volt_switch        " "0,1"
  bitfld.long 0 27. "  boot_mode                " "0,1"
  bitfld.long 0 26. "  disable_boot      " "0,1"
  textline "                         "
  bitfld.long 0 25. "  expect_boot_ack             " "0,1"
  bitfld.long 0 24. "  enable_boot        " "0,1"
  bitfld.long 0 23. "  ccs_expected             " "0,1"
  bitfld.long 0 22. "  read_ceata_device " "0,1"
  textline "                         "
  bitfld.long 0 21. "  update_clock_registers_only " "0,1"
  hexmask.long.byte 0. 16.--20. 1. "  card_number       "
  bitfld.long 0 15. "  send_initialization      " "0,1"
  bitfld.long 0 14. "  stop_abort_cmd    " "0,1"
  textline "                         "
  bitfld.long 0 13. "  wait_prvdata_complete       " "0,1"
  bitfld.long 0 12. "  send_auto_stop     " "0,1"
  bitfld.long 0 11. "  transfer_mode       " " block,stream"
  bitfld.long 0 10. "  rw                " "read,write"
  textline "                         "
  bitfld.long 0  9. "  data_expected             " "no,yes"
  bitfld.long 0  8. "  check_response_crc " "0,1"
  bitfld.long 0  7. "  response_length      " "short,long"
  bitfld.long 0  6. "  response_expect   " "no,yes"
  textline "                         "
  decmask.long.byte 0 0.--5. 1. "  cmd_index                "
group 0x030--0x033
 line.long 0 "RESP0"
group 0x034--0x037
 line.long 0 "RESP1"
group 0x038--0x03B
 line.long 0 "RESP2"
group 0x03C--0x03F
 line.long 0 "RESP3"
group 0x040--0x043
 line.long 0 "MINTSTS"
group 0x044--0x047
 line.long 0 "RINTSTS"
  eventfld.long 0 15. ": ,End-bit error (read)/write no CRC" "----,EBE "
  eventfld.long 0 14. "  ,Auto command done" "----,ACD "
  eventfld.long 0 13. "  ,Start-bit error" "----,SBE "
  eventfld.long 0 12. "  ,Hardware locked write error" "----,HLE "
  eventfld.long 0 11. "  ,FIFO underrun/overrun error" "----,FRUN"
  eventfld.long 0 10. "  ,Data starvation-by-host timeout" "----,HTO "
  eventfld.long 0  9. "  ,Data read timeout" "----,DRTO"
  eventfld.long 0  8. "  ,Response timeout" "---,RTO"
  textline "                         "
  eventfld.long 0  7. "  ,Data CRC error" "----,DCRC"
  eventfld.long 0  6. "  ,Response CRC error" "----,RCRC"
  eventfld.long 0  5. "  ,Receive FIFO data request" "----,RXDR"
  eventfld.long 0  4. "  ,Transmit FIFO data request (TXDR)" "----,TXDR"
  eventfld.long 0  3. "  ,Data transfer over" "----,DTO "
  eventfld.long 0  2. "  ,Command done" "----,CMDD"
  eventfld.long 0  1. "  ,Response error" "----,RE  "
  eventfld.long 0  0. "  ,Card detect" "---,CD "
rgroup 0x048--0x04B
 line.long 0 "STATUS"
  bitfld.long 0 31. ": dma_req            ,DMA request signal state" "0,1"
  bitfld.long 0 30. "  dma_ack    ,DMA DMA request signal state signal state" "0,1"
  hexmask.long.word 0 17.--29. 1 "  fifo_count     ,Number of filled locations in FIFO"
  decmask.long.byte 0 11.--16. 1 "  response_index     ,Index of previous response"
  textline "                         "
  bitfld.long 0 10. "  data_state_mc_busy ,Data transmit or receive state-machine is busy" "0,1"
  bitfld.long 0 9.  "  data_busy  ,Inverted version of raw selected card_data[0]" "0,1"
  bitfld.long 0 8.  "  data_3_status     ,Raw selected card_data[3]" "0,1"
  bitfld.long 0 4.--7. "  command_fsm_states " "Idle,Send init sequence,Tx cmd start bit,Tx cmd tx bit,Tx cmd index + arg,Tx cmd crc7,Tx cmd end bit,Rx resp start bit,Rx resp IRQ response,Rx resp tx bit,Rx resp cmd idx,Rx resp data,Rx resp crc7,Rx resp end bit,Cmd path wait NCC,Wait CMD-to-response turnaround"
  textline "                         "
  bitfld.long 0 3.  "  fifo_full          ,FIFO is full status" "0,1"
  bitfld.long 0 2.  "  fifo_empty ,FIFO is empty status" "0,1"
  bitfld.long 0 1.  "  fifo_tx_watermark ,FIFO reached Transmit watermark level" "0,1"
  bitfld.long 0 0.  "  fifo_rx_watermark  ,FIFO reached Receive watermark level" "0,1"
group 0x04C--0x04F
 line.long 0 "FIFOTH"
group 0x050--0x053
 line.long 0 "CDETECT"
group 0x054--0x057
 line.long 0 "WRTPRT"
group 0x058--0x05B
 line.long 0 "GPIO"
group 0x05C--0x05F
 line.long 0 "TCBCNT"
group 0x060--0x063
 line.long 0 "TBBCNT"
group 0x064--0x067
 line.long 0 "DEBNCE"
group 0x068--0x06B
 line.long 0 "USRID"
group 0x06C--0x06F
 line.long 0 "VERID"
rgroup 0x070--0x073
 line.long 0 "HCON"
  bitfld.long 0 26.--26. ": AREA_OPTIMIZED " "no,yes"
  bitfld.long 0 24.--25. "  NUM_CLK_DIVIDER " "1,2,3,4"
  bitfld.long 0 23.--23. "  SET_CLK_FALSE_PATH " "no,yes"
  bitfld.long 0 22.--22. "  IMPLEMENT_HOLD_REG " "no,yes"
  textline "                         "
  bitfld.long 0 21.--21. "  FIFO_RAM_INSIDE " "no,yes"
  bitfld.long 0 18.--20. "  GE_DMA_DATA_WIDTH " "16,32,64,-,-,-,-,-"
  bitfld.long 0 16.--17. "  DMA_INTERFACE " "none,DW_DMA,GENERIC_DMA,NON-DW-DMA"
  bitfld.long 0 26.--26. "  AREA_OPTIMIZED " "no,yes"
  textline "                         "
  hexmask.long.byte 0 10.--15. 1. "  H_ADDR_WIDTH "
  bitfld.long 0 7.--9. "  H_DATA_WIDTH " "16,32,64,-,-,-,-,-"
  bitfld.long 0 6.--6. "  H_BUS_TYPE " "APB,AHB"
  bitfld.long 0 1.--5. "  NUM_CARDS " "1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16"
  textline "                         "
  bitfld.long 0 0.--0. "  CARD_TYPE " "MMC_ONLY,SD_MMC"

group 0x074--0x077
 line.long 0 "UHS_REG"
group 0x078--0x07B
 line.long 0 "RST_n"
group 0x080--0x083
 line.long 0 "BMOD"
  bitfld.long 0 8.--10. ": PBL ,Programmable Burst Length" "1,4,8,16,32,64,128,256"
  bitfld.long 0 7. "  DE ,IDMAC Enable" "0,1"
  hexmask.long.byte 0 2.--6. 1. "  DSL ,Descriptor Skip Length"
  bitfld.long 0 1. "  FB ,Fixed Burst" "0,1"
  bitfld.long 0 0. "  SWR ,Software Reset" "0,1"
group 0x084--0x087
 line.long 0 "PLDMND"
group 0x088--0x08B
 line.long 0 "DBADDR"
group 0x08C--0x08F
 line.long 0 "IDSTS"
  bitfld.long 0 13.--16. ": FSM ,DMAC FSM present state" "DMA_IDLE,DMA_SUSPEND,DESC_RD,DESC_CHK,DMA_RD_REQ_WAIT,DMA_WR_REQ_WAIT,DMA_RD,DMA_WR,DESC_CLOSE"
  bitfld.long 0 10.--12. "  EB ,Error Bits" "-,AbtTrn,AbtRcv"
  bitfld.long 0 9. "  AIS ,Abnormal Interrupt Summary" "0,1"
  bitfld.long 0 8. "  NIS ,Normal Interrupt Summary" "0,1"
  bitfld.long 0 5. "  CES ,Card Error Summary" "0,1"
  bitfld.long 0 4. "  DU ,Descriptor Unavailable Interrupt" "0,1"
  bitfld.long 0 2. "  FBE ,Fatal Bus Error Interrupt" "0,1"
  bitfld.long 0 1. "  RI ,Receive Interrupt" "0,1"
  bitfld.long 0 0. "  TI ,Transmit Interrupt" "0,1"
group 0x090--0x093
 line.long 0 "IDINTEN"
group 0x094--0x097
 line.long 0 "DSCADDR"
group 0x098--0x09B
 line.long 0 "BUFADDR"
group 0x100--0x103
 line.long 0 "CardThrCtl"
group 0x104--0x107
 line.long 0 "Back_end_power"
tree.end

;=====================================================
tree "FC       - NAND Flash / LCD Controller"
;=====================================================
base a:0x05400000
group 0x000--0x003
 line.long 0 "FC_CTL"
  textline ""
  bitfld.long  0 0.--1.     "    ECC_OP_MODE           ," "1 bit,4 bits,8 bits,12 bits"
  textline ""
  bitfld.long  0 10.        "    LCD_IM                ," "0,1"
  textline ""
  bitfld.long  0 10.        "    LCD_CLE_INV           ," "0,1"
  textline ""
  bitfld.long 0 16.--28.    "    CHIEN_COUNT_START     ," "    "
rgroup 0x004--0x007
 line.long 0 "FC_STATUS"
  textline ""
  bitfld.long  0  0.        "    TRANSACTION_DONE      ," "0,1"
  textline ""
  bitfld.long  0  1.        "    ECC_DONE              ," "0,1"
  textline ""
  bitfld.long  0  2.        "    ERR_FOUND             ," "0,1"
  textline ""
  bitfld.long  0  3.        "    READY_TIMEOUT_STAT    ," "0,1"
  textline ""
  bitfld.long  0  4.        "    READY1_RISE_INT_STAT  ," "0,1"
  textline ""
  bitfld.long  0  5.        "    READY2_RISE_INT_STAT  ," "0,1"
  textline ""
  bitfld.long  0  6.        "    TRANSACTION_BUSY      ," "0,1"
  textline ""
  bitfld.long  0  7.        "    ECC_BUSY              ," "0,1"
  textline ""
  bitfld.long  0  8.        "    READY1                ," "0,1"
  textline ""
  bitfld.long  0  9.        "    READY2                ," "0,1"
  textline ""
  bitfld.long  0 10.        "    ECC_ERR_FF            ," "0,1"
  textline ""
  bitfld.long  0 11.        "    ECC_NC_ERR            ," "0,1"
  textline ""
  bitfld.long  0 12.--15.   "    ECC_NC_SEQ            ," "  "
  textline ""
  bitfld.long  0 16.        "    AHB_ERR               ," "0,1"
  textline ""
  bitfld.long  0 17.        "    AHB_DONE              ," "0,1"
wgroup 0x008--0x00B
 hide.long 0 "FC_STS_CLR"
group 0x00C--0x00F
 line.long 0 "FC_INT_EN"
  textline ""
  bitfld.long  0  0.        "    TRANSACTION_DONE_IE   ," "0,1"
  textline ""
  bitfld.long  0  1.        "    ECC_DONE_IE           ," "0,1"
  textline ""
  bitfld.long  0  2.        "    ERR_FOUND_IE          ," "0,1"
  textline ""
  bitfld.long  0  3.        "    READY_TIMEOUT_IE      ," "0,1"
  textline ""
  bitfld.long  0  4.        "    READY1_RISE_IE        ," "0,1"
  textline ""
  bitfld.long  0  5.        "    READY2_RISE_IE        ," "0,1"
  textline ""
  bitfld.long  0 10.        "    ECC_ERR_FF_IE         ," "0,1"
  textline ""
  bitfld.long  0 11.        "    ECC_NC_ERR_IE         ," "0,1"
  textline ""
  bitfld.long  0 16.        "    AHB_ERR_IE            ," "0,1"
  textline ""
  bitfld.long  0 17.        "    AHB_DONE_IE           ," "0,1"
rgroup 0x010--0x013
 line.long 0 "FC_INT_CAUSE"
  textline ""
  bitfld.long  0  0.        "    TRANSACTION_DONE_CAUSE," "0,1"
  textline ""
  bitfld.long  0  1.        "    ECC_DONE_CAUSE        ," "0,1"
  textline ""
  bitfld.long  0  2.        "    ERR_FOUND_CAUSE       ," "0,1"
  textline ""
  bitfld.long  0  3.        "    READY_TIMEOUT_CAUSE   ," "0,1"
  textline ""
  bitfld.long  0  4.        "    READY1_RISE_CAUSE     ," "0,1"
  textline ""
  bitfld.long  0  5.        "    READY2_RISE_CAUSE     ," "0,1"
  textline ""
  bitfld.long  0 10.        "    ECC_ERR_FF_CAUSE      ," "0,1"
  textline ""
  bitfld.long  0 11.        "    ECC_NC_ERR_CAUSE      ," "0,1"
  textline ""
  bitfld.long  0 16.        "    AHB_ERR_CAUSE         ," "0,1"
group 0x014--0x017
 line.long 0 "FC_SEQUENCE"
  textline ""
  bitfld.long  0  0.        "    CMD1_EN               ," "0,1"
  textline ""
  bitfld.long  0  1.        "    WAIT0_EN              ," "0,1"
  textline ""
  bitfld.long  0  2.        "    ADD1_EN               ," "0,1"
  textline ""
  bitfld.long  0  3.        "    ADD2_EN               ," "0,1"
  textline ""
  bitfld.long  0  4.        "    ADD3_EN               ," "0,1"
  textline ""
  bitfld.long  0  5.        "    ADD4_EN               ," "0,1"
  textline ""
  bitfld.long  0  6.        "    ADD5_EN               ," "0,1"
  textline ""
  bitfld.long  0  7.        "    WAIT1_EN              ," "0,1"
  textline ""
  bitfld.long  0  8.        "    CMD2_EN               ," "0,1"
  textline ""
  bitfld.long  0  9.        "    WAIT2_EN              ," "0,1"
  textline ""
  bitfld.long  0 10.        "    DATA_RW_EN            ," "0,1"
  textline ""
  bitfld.long  0 11.        "    DATA_RW_DIR           ," "0,1"
  textline ""
  bitfld.long  0 12.        "    DATA_ECC_EN           ," "0,1"
  textline ""
  bitfld.long  0 13.        "    CMD3_EN               ," "0,1"
  textline ""
  bitfld.long  0 14.        "    WAIT3_EN              ," "0,1"
  textline ""
  bitfld.long  0 15.        "    CMD4_EN               ," "0,1"
  textline ""
  bitfld.long  0 16.        "    WAIT4_EN              ," "0,1"
  textline ""
  bitfld.long  0 17.        "    READ_ONCE_EN          ," "0,1"
  textline ""
  bitfld.long  0 18.--19.   "    CHIP_SEL              ," "0,1,2,3"
  textline ""
  bitfld.long  0 20.        "    KEEP_CS               ," "0,1"
  textline ""
  bitfld.long  0 21.        "    NAND16_EN             ," "0,1"
  textline ""
  bitfld.long  0 22.        "    READY_EN              ," "0,1"
  textline ""
  bitfld.long  0 23.        "    READY_SEL             ," "0,1"
  textline ""
  bitfld.long  0 24.        "    CMD5_EN               ," "0,1"
  textline ""
  bitfld.long  0 25.        "    WAIT5_EN              ," "0,1"
  textline ""
  bitfld.long  0 26.        "    CMD6_EN               ," "0,1"
  textline ""
  bitfld.long  0 27.        "    WAIT6_EN              ," "0,1"
group 0x018--0x01B
 line.long 0 "FC_ADDR_COL"
  textline ""
  bitfld.long  0  0.--7.  "    ADD1                  ," "   "
  textline ""
  bitfld.long  0  8.--15. "    ADD2                  ," "   "
group 0x01C--0x01F
 line.long 0 "FC_ADDR_ROW"
  textline ""
  bitfld.long 0  0.--7.  "    ADD3                  ," "   "
  textline ""
  bitfld.long 0  8.--15. "    ADD4                  ," "   "
  textline ""
  bitfld.long 0 16.--23. "    ADD5                  ," "   "
group 0x020--0x023
 line.long 0 "FC_CMD1"
  textline ""
  bitfld.long 0  0.--7.  "    CMD1                  ," "   "
  textline ""
  bitfld.long 0  8.--15. "    CMD2                  ," "   "
  textline ""
  bitfld.long 0 16.--23. "    CMD3                  ," "   "
  textline ""
  bitfld.long 0 24.--31. "    CMD4                  ," "   "
group 0x024--0x027
 line.long 0 "FC_CMD2"
  textline ""
  bitfld.long 0  0.--7.  "    CMD5                  ," "   "
  textline ""
  bitfld.long 0  8.--15. "    CMD6                  ," "   "
group 0x028--0x02B
 line.long 0 "FC_WAIT1"
  textline ""
  bitfld.long 0 24.--29. "    WAIT2B                ," "   "
  textline ""
  bitfld.long 0 16.--21. "    WAIT2A                ," "   "
  textline ""
  bitfld.long 0  8.--13. "    WAIT1B                ," "   "
  textline ""
  bitfld.long 0  0.--5.  "    WAIT1A                ," "   "
group 0x02C--0x02F
 line.long 0 "FC_WAIT2"
  textline ""
  bitfld.long 0 24.--29. "    WAIT4B                ," "   "
  textline ""
  bitfld.long 0 16.--21. "    WAIT4A                ," "   "
  textline ""
  bitfld.long 0  8.--13. "    WAIT3B                ," "   "
  textline ""
  bitfld.long 0  0.--5.  "    WAIT3A                ," "   "
group 0x030--0x033
 line.long 0 "FC_WAIT3"
  textline ""
  bitfld.long 0 24.--29. "    WAIT6B                ," "   "
  textline ""
  bitfld.long 0 16.--21. "    WAIT6A                ," "   "
  textline ""
  bitfld.long 0  8.--13. "    WAIT5B                ," "   "
  textline ""
  bitfld.long 0  0.--5.  "    WAIT5A                ," "   "
group 0x034--0x037
 line.long 0 "FC_WAIT4"
  textline ""
  bitfld.long 0  8.--13. "    WAIT0B                ," "   "
  textline ""
  bitfld.long 0  0.--5.  "    WAIT0A                ," "   "
group 0x038--0x03B
 line.long 0 "FC_PULSETIME"
  textline ""
  bitfld.long 0  0.--3.  "    READ_LOW              ," "   "
  textline ""
  bitfld.long 0  4.--7.  "    READ_HIGH             ," "   "
  textline ""
  bitfld.long 0  8.--11. "    WRITE_LOW             ," "   "
  textline ""
  bitfld.long 0 12.--15. "    WRITE_HIGH            ," "   "
  textline ""
  bitfld.long 0 16.--19. "    CLE_SETUP             ," "   "
  textline ""
  bitfld.long 0 20.--23. "    ALE_SETUP             ," "   "
  textline ""
  bitfld.long 0 24.--29. "    SPARE_WORDS           ," "   "
group 0x03C--0x03F
 line.long 0 "FC_DCOUNT"
  textline ""
  bitfld.long 0  0.--12. "    VP_SIZE               ," "   "
  textline ""
  bitfld.long 0 13.--15. "    SPARE_N3_COUNT        ," "   "
  textline ""
  bitfld.long 0 16.--23. "    SPARE_N2_COUNT        ," "   "
  textline ""
  bitfld.long 0 24.--27. "    SPARE_N1_COUNT        ," "   "
  textline ""
  bitfld.long 0 28.--31. "    VIRTUAL_PAGE_COUNT    ," "   "
group 0x040--0x043
 line.long 0 "FC_FTSR"
  textline ""
  bitfld.long 0  0.--12. "    TRANSFER_SIZE         ," "    "
  textline ""
  bitfld.long 0 16.--19. "    SEQ_NUM               ," "    "
  textline ""
  bitfld.long 0 20.--23. "    STRT_VP_NUM           ," "    "
group 0x044--0x047
 line.long 0 "FC_DPR"
group 0x048--0x04B
 line.long 0 "FC_RDPR"
group 0x04C--0x04F
 line.long 0 "FC_TIMEOUT"
  textline ""
  bitfld.long  0 8.       "    READY_TIMEOUT_EN      ," "0,1"
  textline ""
  bitfld.long  0 20.--23. "    READY_TIMEOUT_COUNT   ," "   "
rgroup 0x050--0x053
 line.long 0 "FC_BCH"
  textline ""
  bitfld.long  0  0.--12. "    BCH_ERR_LOC           ," "   "
  textline ""
  bitfld.long  0 13.--16. "    BCH_ERR_SEQ           ," "   "
rgroup 0x054--0x057
 line.long 0 "FC_HAMMING"
  textline ""
  bitfld.long  0 14.--17. "    HAM_ERR_SEQ           ," "   "
  textline ""
  bitfld.long  0  0.--13. "    HAMMING_ERR_LOC       ," "   "
group 0x058--0x05B
 hide.long 0 "FC_START"
group 0x05C--0x05F
 line.long 0 "FC_FBYP_CRL"
  textline ""
  bitfld.long  0  4.      "    BP_READ               ," "0,1"
  textline ""
  bitfld.long  0  2.      "    BP_WRITE              ," "0,1"
  textline ""
  bitfld.long  0  1.      "    BP_EN                 ," "0,1"
  textline ""
  bitfld.long  0  0.      "    BUSY_STS              ," "0,1"
rgroup 0x060--0x063
 hide.long 0 "FC_FBYP_DAT"
  in
group 0x064--0x067
 line.long 0 "FC_LCD_HADD"
group 0x068--0x06B
 line.long 0 "CHIEN_COEFF_1"
group 0x06C--0x06F
 line.long 0 "CHIEN_COEFF_2"
group 0x070--0x073
 line.long 0 "CHIEN_COEFF_3"
group 0x074--0x077
 line.long 0 "CHIEN_COEFF_4"
group 0x078--0x07B
 line.long 0 "CHIEN_COEFF_5"
group 0x07C--0x07F
 line.long 0 "CHIEN_COEFF_6"
group 0x080--0x083
 line.long 0 "CHIEN_COEFF_7"
group 0x084--0x087
 line.long 0 "CHIEN_COEFF_8"
group 0x088--0x08B
 line.long 0 "CHIEN_COEFF_9"
group 0x08C--0x08F
 line.long 0 "CHIEN_COEFF_10"
group 0x090--0x093
 line.long 0 "CHIEN_COEFF_11"
group 0x094--0x097
 line.long 0 "CHIEN_COEFF_12"
group 0x098--0x09B
 line.long 0 "CHIEN_COEFF_13"
group 0x09C--0x09F
 line.long 0 "CHIEN_COEFF_14"
group 0x0a0--0x0a3
 line.long 0 "CHIEN_COEFF_15"
group 0x0a4--0x0a7
 line.long 0 "CHIEN_COEFF_16"
group 0x0a8--0x0aB
 line.long 0 "CHIEN_COEFF_17"
group 0x0aC--0x0aF
 line.long 0 "CHIEN_COEFF_18"
group 0x0b0--0x0b3
 line.long 0 "CHIEN_COEFF_19"
group 0x0b4--0x0b7
 line.long 0 "CHIEN_COEFF_20"
group 0x0b8--0x0bB
 line.long 0 "CHIEN_COEFF_21"
group 0x0bC--0x0bF
 line.long 0 "CHIEN_COEFF_22"
group 0x0c0--0x0c3
 line.long 0 "CHIEN_COEFF_23"
group 0x0c4--0x0c7
 line.long 0 "CHIEN_COEFF_24"
 group 0x0C8--0x0CB
 line.long 0 "FC_AHB_CTL"
group 0x0CC--0x0CF
 line.long 0 "FC_AHB_DBG_1"
group 0x0D0--0x0D3
 line.long 0 "FC_AHB_DBG_2"
group 0x0D4--0x0D7
 line.long 0 "FC_DBG_1"
group 0x0D8--0x0DB
 line.long 0 "FC_DBG_2"
group 0x0DC--0x0DF
 line.long 0 "FC_ECC_DBG_1"
group 0x0E0--0x0E3
 line.long 0 "FC_ECC_DBG_2"
group 0x0E4--0x0E7
 line.long 0 "FC_ECC_DBG_3"
group 0x0E8--0x0EB
 line.long 0 "FC_ECC_DBG_4"
group 0x0EC--0x0EF
 line.long 0 "FC_ECC_DBG_5"
tree.end

;=====================================================
tree "GDMAC    - Generic DMA Controller"
;=====================================================
base a:0x06400000
rgroup 0x000--0x003
 line.long 0 "CEMSR"
wgroup 0x004--0x007
 line.long 0 "CER"
wgroup 0x008--0x00B
 line.long 0 "CDR"
group 0x00C--0x00F
 line.long 0 "CTOR"
group 0x010--0x013
 line.long 0 "CCIER"
group 0x014--0x017
 line.long 0 "CDIER"
rgroup 0x018--0x01B
 line.long 0 "CCICR"
rgroup 0x01C--0x01F
 line.long 0 "CDICR"
wgroup 0x020--0x023
 line.long 0 "CCICLR"
wgroup 0x024--0x027
 line.long 0 "CDICLR"
group 0x028--0x02B
 line.long 0 "CRDR"
group 0x02C--0x02F
 line.long 0 "CTOENR"
group 0x030--0x033
 line.long 0 "CTERENR"
rgroup 0x034--0x037
 line.long 0 "CTOCR"
rgroup 0x038--0x03B
 line.long 0 "CTECR"
wgroup 0x03C--0x03F
 line.long 0 "CTOCLR"
wgroup 0x040--0x043
 line.long 0 "CTECLR"
group 0x044--0x047
 line.long 0 "CRCONF1"
group 0x048--0x04B
 line.long 0 "CRCONF2"
group 0x04C--0x04F
 line.long 0 "CRCONF3"
group 0x050--0x053
 line.long 0 "CRCONF4"
group 0x054--0x057
 line.long 0 "CRCONF5"
group 0x058--0x05B
 line.long 0 "CRCONF6"
group 0x05C--0x05F
 line.long 0 "CDPR"
group 0x060--0x063
 line.long 0 "C0DESCADR"
group 0x064--0x067
 line.long 0 "C1DESCADR"
group 0x068--0x06B
 line.long 0 "C2DESCADR"
group 0x06C--0x06F
 line.long 0 "C3DESCADR"
group 0x070--0x073
 line.long 0 "C4DESCADR"
group 0x074--0x077
 line.long 0 "C5DESCADR"
group 0x078--0x07B
 line.long 0 "C6DESCADR"
group 0x07C--0x07F
 line.long 0 "C7DESCADR"
group 0x080--0x083
 line.long 0 "C8DESCADR"
group 0x084--0x087
 line.long 0 "C9DESCADR"
group 0x088--0x08B
 line.long 0 "C10DESCADR"
group 0x08C--0x08F
 line.long 0 "C11DESCADR"
group 0x090--0x093
 line.long 0 "C12DESCADR"
group 0x094--0x097
 line.long 0 "C13DESCADR"
group 0x098--0x09B
 line.long 0 "C14DESCADR"
group 0x09C--0x09F
 line.long 0 "C15DESCADR"
group 0x0A0--0x0A3
 line.long 0 "C16DESCADR"
group 0x0A4--0x0A7
 line.long 0 "C17DESCADR"
group 0x0A8--0x0AB
 line.long 0 "C18DESCADR"
group 0x0AC--0x0AF
 line.long 0 "C19DESCADR"
group 0x0B0--0x0B3
 line.long 0 "C20DESCADR"
group 0x0B4--0x0B7
 line.long 0 "C21DESCADR"
group 0x0B8--0x0BB
 line.long 0 "C22DESCADR"
group 0x0BC--0x0BF
 line.long 0 "C23DESCADR"
group 0x0C0--0x0C3
 line.long 0 "C24DESCADR"
group 0x0C4--0x0C7
 line.long 0 "C25DESCADR"
group 0x0C8--0x0CB
 line.long 0 "C26DESCADR"
group 0x0CC--0x0CF
 line.long 0 "C27DESCADR"
group 0x0D0--0x0D3
 line.long 0 "C28DESCADR"
group 0x0D4--0x0D7
 line.long 0 "C29DESCADR"
group 0x0D8--0x0DB
 line.long 0 "C30DESCADR"
group 0x0DC--0x0DF
 line.long 0 "C31DESCADR"
rgroup 0x0E0--0x0E3
 line.long 0 "C0RTC"
rgroup 0x0E4--0x0E7
 line.long 0 "C1RTC"
rgroup 0x0E8--0x0EB
 line.long 0 "C2RTC"
rgroup 0x0EC--0x0EF
 line.long 0 "C3RTC"
rgroup 0x0F0--0x0F3
 line.long 0 "C4RTC"
rgroup 0x0F4--0x0F7
 line.long 0 "C5RTC"
rgroup 0x0F8--0x0FB
 line.long 0 "C6RTC"
rgroup 0x0FC--0x0FF
 line.long 0 "C7RTC"
rgroup 0x100--0x103
 line.long 0 "C8RTC"
rgroup 0x104--0x107
 line.long 0 "C9RTC"
rgroup 0x108--0x10B
 line.long 0 "C10RTC"
rgroup 0x10C--0x10F
 line.long 0 "C11RTC"
rgroup 0x110--0x113
 line.long 0 "C12RTC"
rgroup 0x114--0x117
 line.long 0 "C13RTC"
rgroup 0x118--0x11B
 line.long 0 "C14RTC"
rgroup 0x11C--0x11F
 line.long 0 "C15RTC"
rgroup 0x120--0x123
 line.long 0 "C16RTC"
rgroup 0x124--0x127
 line.long 0 "C17RTC"
rgroup 0x128--0x12B
 line.long 0 "C18RTC"
rgroup 0x12C--0x12F
 line.long 0 "C19RTC"
rgroup 0x130--0x133
 line.long 0 "C20RTC"
rgroup 0x134--0x137
 line.long 0 "C21RTC"
rgroup 0x138--0x13B
 line.long 0 "C22RTC"
rgroup 0x13C--0x13F
 line.long 0 "C23RTC"
rgroup 0x140--0x143
 line.long 0 "C24RTC"
rgroup 0x144--0x147
 line.long 0 "C25RTC"
rgroup 0x148--0x14B
 line.long 0 "C26RTC"
rgroup 0x14C--0x14F
 line.long 0 "C27RTC"
rgroup 0x150--0x153
 line.long 0 "C28RTC"
rgroup 0x154--0x157
 line.long 0 "C29RTC"
rgroup 0x158--0x15B
 line.long 0 "C30RTC"
rgroup 0x15C--0x15F
 line.long 0 "C31RTC"
rgroup 0x160--0x163
 line.long 0 "DBGFIFOLVL"
rgroup 0x164--0x167
 line.long 0 "DBGPORTA"
rgroup 0x168--0x16B
 line.long 0 "DBGPORTB"
rgroup 0x16C--0x16F
 line.long 0 "DBGFSM"
rgroup 0x170--0x17e
 line.long 0 "DBGSPARE"
tree.end

;=====================================================
tree "GPIO     - General Purpose IO and Keypad"
;=====================================================
base a:0x05000000
tree "Port A"
group 0x000--0x05F
  textline ""
  setclrfld.long 0x18 31. 0x1C 31. 0x20 31. "  31  " "disabled,ENABLED"
  setclrfld.long 0x00 31. 0x04 31. 0x08 31. "  Data " "0,1"
  setclrfld.long 0x0C 31. 0x14 31. 0x10 31. "  Dir " "out,in "
  setclrfld.long 0x24 31. 0x28 31. 0x2C 31. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 31. 0x34 31. 0x38 31. "  PullType " "down,up"
  setclrfld.long 0x3C 31. 0x40 31. 0x44 31. "  Keep " "off,ON"
  setclrfld.long 0x48 31. 0x4C 31. 0x50 31. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 30. 0x1C 30. 0x20 30. "  30  " "disabled,ENABLED"
  setclrfld.long 0x00 30. 0x04 30. 0x08 30. "  Data " "0,1"
  setclrfld.long 0x0C 30. 0x14 30. 0x10 30. "  Dir " "out,in "
  setclrfld.long 0x24 30. 0x28 30. 0x2C 30. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 30. 0x34 30. 0x38 30. "  PullType " "down,up"
  setclrfld.long 0x3C 30. 0x40 30. 0x44 30. "  Keep " "off,ON"
  setclrfld.long 0x48 30. 0x4C 30. 0x50 30. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 29. 0x1C 29. 0x20 29. "  29  " "disabled,ENABLED"
  setclrfld.long 0x00 29. 0x04 29. 0x08 29. "  Data " "0,1"
  setclrfld.long 0x0C 29. 0x14 29. 0x10 29. "  Dir " "out,in "
  setclrfld.long 0x24 29. 0x28 29. 0x2C 29. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 29. 0x34 29. 0x38 29. "  PullType " "down,up"
  setclrfld.long 0x3C 29. 0x40 29. 0x44 29. "  Keep " "off,ON"
  setclrfld.long 0x48 29. 0x4C 29. 0x50 29. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 28. 0x1C 28. 0x20 28. "  28  " "disabled,ENABLED"
  setclrfld.long 0x00 28. 0x04 28. 0x08 28. "  Data " "0,1"
  setclrfld.long 0x0C 28. 0x14 28. 0x10 28. "  Dir " "out,in "
  setclrfld.long 0x24 28. 0x28 28. 0x2C 28. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 28. 0x34 28. 0x38 28. "  PullType " "down,up"
  setclrfld.long 0x3C 28. 0x40 28. 0x44 28. "  Keep " "off,ON"
  setclrfld.long 0x48 28. 0x4C 28. 0x50 28. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 27. 0x1C 27. 0x20 27. "  27  " "disabled,ENABLED"
  setclrfld.long 0x00 27. 0x04 27. 0x08 27. "  Data " "0,1"
  setclrfld.long 0x0C 27. 0x14 27. 0x10 27. "  Dir " "out,in "
  setclrfld.long 0x24 27. 0x28 27. 0x2C 27. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 27. 0x34 27. 0x38 27. "  PullType " "down,up"
  setclrfld.long 0x3C 27. 0x40 27. 0x44 27. "  Keep " "off,ON"
  setclrfld.long 0x48 27. 0x4C 27. 0x50 27. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 26. 0x1C 26. 0x20 26. "  26  " "disabled,ENABLED"
  setclrfld.long 0x00 26. 0x04 26. 0x08 26. "  Data " "0,1"
  setclrfld.long 0x0C 26. 0x14 26. 0x10 26. "  Dir " "out,in "
  setclrfld.long 0x24 26. 0x28 26. 0x2C 26. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 26. 0x34 26. 0x38 26. "  PullType " "down,up"
  setclrfld.long 0x3C 26. 0x40 26. 0x44 26. "  Keep " "off,ON"
  setclrfld.long 0x48 26. 0x4C 26. 0x50 26. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 25. 0x1C 25. 0x20 25. "  25  " "disabled,ENABLED"
  setclrfld.long 0x00 25. 0x04 25. 0x08 25. "  Data " "0,1"
  setclrfld.long 0x0C 25. 0x14 25. 0x10 25. "  Dir " "out,in "
  setclrfld.long 0x24 25. 0x28 25. 0x2C 25. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 25. 0x34 25. 0x38 25. "  PullType " "down,up"
  setclrfld.long 0x3C 25. 0x40 25. 0x44 25. "  Keep " "off,ON"
  setclrfld.long 0x48 25. 0x4C 25. 0x50 25. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 24. 0x1C 24. 0x20 24. "  24  " "disabled,ENABLED"
  setclrfld.long 0x00 24. 0x04 24. 0x08 24. "  Data " "0,1"
  setclrfld.long 0x0C 24. 0x14 24. 0x10 24. "  Dir " "out,in "
  setclrfld.long 0x24 24. 0x28 24. 0x2C 24. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 24. 0x34 24. 0x38 24. "  PullType " "down,up"
  setclrfld.long 0x3C 24. 0x40 24. 0x44 24. "  Keep " "off,ON"
  setclrfld.long 0x48 24. 0x4C 24. 0x50 24. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 23. 0x1C 23. 0x20 23. "  23  " "disabled,ENABLED"
  setclrfld.long 0x00 23. 0x04 23. 0x08 23. "  Data " "0,1"
  setclrfld.long 0x0C 23. 0x14 23. 0x10 23. "  Dir " "out,in "
  setclrfld.long 0x24 23. 0x28 23. 0x2C 23. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 23. 0x34 23. 0x38 23. "  PullType " "down,up"
  setclrfld.long 0x3C 23. 0x40 23. 0x44 23. "  Keep " "off,ON"
  setclrfld.long 0x48 23. 0x4C 23. 0x50 23. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 22. 0x1C 22. 0x20 22. "  22  " "disabled,ENABLED"
  setclrfld.long 0x00 22. 0x04 22. 0x08 22. "  Data " "0,1"
  setclrfld.long 0x0C 22. 0x14 22. 0x10 22. "  Dir " "out,in "
  setclrfld.long 0x24 22. 0x28 22. 0x2C 22. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 22. 0x34 22. 0x38 22. "  PullType " "down,up"
  setclrfld.long 0x3C 22. 0x40 22. 0x44 22. "  Keep " "off,ON"
  setclrfld.long 0x48 22. 0x4C 22. 0x50 22. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 21. 0x1C 21. 0x20 21. "  21  " "disabled,ENABLED"
  setclrfld.long 0x00 21. 0x04 21. 0x08 21. "  Data " "0,1"
  setclrfld.long 0x0C 21. 0x14 21. 0x10 21. "  Dir " "out,in "
  setclrfld.long 0x24 21. 0x28 21. 0x2C 21. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 21. 0x34 21. 0x38 21. "  PullType " "down,up"
  setclrfld.long 0x3C 21. 0x40 21. 0x44 21. "  Keep " "off,ON"
  setclrfld.long 0x48 21. 0x4C 21. 0x50 21. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 20. 0x1C 20. 0x20 20. "  20  " "disabled,ENABLED"
  setclrfld.long 0x00 20. 0x04 20. 0x08 20. "  Data " "0,1"
  setclrfld.long 0x0C 20. 0x14 20. 0x10 20. "  Dir " "out,in "
  setclrfld.long 0x24 20. 0x28 20. 0x2C 20. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 20. 0x34 20. 0x38 20. "  PullType " "down,up"
  setclrfld.long 0x3C 20. 0x40 20. 0x44 20. "  Keep " "off,ON"
  setclrfld.long 0x48 20. 0x4C 20. 0x50 20. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 19. 0x1C 19. 0x20 19. "  19  " "disabled,ENABLED"
  setclrfld.long 0x00 19. 0x04 19. 0x08 19. "  Data " "0,1"
  setclrfld.long 0x0C 19. 0x14 19. 0x10 19. "  Dir " "out,in "
  setclrfld.long 0x24 19. 0x28 19. 0x2C 19. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 19. 0x34 19. 0x38 19. "  PullType " "down,up"
  setclrfld.long 0x3C 19. 0x40 19. 0x44 19. "  Keep " "off,ON"
  setclrfld.long 0x48 19. 0x4C 19. 0x50 19. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 18. 0x1C 18. 0x20 18. "  18  " "disabled,ENABLED"
  setclrfld.long 0x00 18. 0x04 18. 0x08 18. "  Data " "0,1"
  setclrfld.long 0x0C 18. 0x14 18. 0x10 18. "  Dir " "out,in "
  setclrfld.long 0x24 18. 0x28 18. 0x2C 18. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 18. 0x34 18. 0x38 18. "  PullType " "down,up"
  setclrfld.long 0x3C 18. 0x40 18. 0x44 18. "  Keep " "off,ON"
  setclrfld.long 0x48 18. 0x4C 18. 0x50 18. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 17. 0x1C 17. 0x20 17. "  17  " "disabled,ENABLED"
  setclrfld.long 0x00 17. 0x04 17. 0x08 17. "  Data " "0,1"
  setclrfld.long 0x0C 17. 0x14 17. 0x10 17. "  Dir " "out,in "
  setclrfld.long 0x24 17. 0x28 17. 0x2C 17. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 17. 0x34 17. 0x38 17. "  PullType " "down,up"
  setclrfld.long 0x3C 17. 0x40 17. 0x44 17. "  Keep " "off,ON"
  setclrfld.long 0x48 17. 0x4C 17. 0x50 17. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 16. 0x1C 16. 0x20 16. "  16  " "disabled,ENABLED"
  setclrfld.long 0x00 16. 0x04 16. 0x08 16. "  Data " "0,1"
  setclrfld.long 0x0C 16. 0x14 16. 0x10 16. "  Dir " "out,in "
  setclrfld.long 0x24 16. 0x28 16. 0x2C 16. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 16. 0x34 16. 0x38 16. "  PullType " "down,up"
  setclrfld.long 0x3C 16. 0x40 16. 0x44 16. "  Keep " "off,ON"
  setclrfld.long 0x48 16. 0x4C 16. 0x50 16. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 15. 0x1C 15. 0x20 15. "  15  " "disabled,ENABLED"
  setclrfld.long 0x00 15. 0x04 15. 0x08 15. "  Data " "0,1"
  setclrfld.long 0x0C 15. 0x14 15. 0x10 15. "  Dir " "out,in "
  setclrfld.long 0x24 15. 0x28 15. 0x2C 15. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 15. 0x34 15. 0x38 15. "  PullType " "down,up"
  setclrfld.long 0x3C 15. 0x40 15. 0x44 15. "  Keep " "off,ON"
  setclrfld.long 0x48 15. 0x4C 15. 0x50 15. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 14. 0x1C 14. 0x20 14. "  14  " "disabled,ENABLED"
  setclrfld.long 0x00 14. 0x04 14. 0x08 14. "  Data " "0,1"
  setclrfld.long 0x0C 14. 0x14 14. 0x10 14. "  Dir " "out,in "
  setclrfld.long 0x24 14. 0x28 14. 0x2C 14. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 14. 0x34 14. 0x38 14. "  PullType " "down,up"
  setclrfld.long 0x3C 14. 0x40 14. 0x44 14. "  Keep " "off,ON"
  setclrfld.long 0x48 14. 0x4C 14. 0x50 14. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 13. 0x1C 13. 0x20 13. "  13  " "disabled,ENABLED"
  setclrfld.long 0x00 13. 0x04 13. 0x08 13. "  Data " "0,1"
  setclrfld.long 0x0C 13. 0x14 13. 0x10 13. "  Dir " "out,in "
  setclrfld.long 0x24 13. 0x28 13. 0x2C 13. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 13. 0x34 13. 0x38 13. "  PullType " "down,up"
  setclrfld.long 0x3C 13. 0x40 13. 0x44 13. "  Keep " "off,ON"
  setclrfld.long 0x48 13. 0x4C 13. 0x50 13. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 12. 0x1C 12. 0x20 12. "  12  " "disabled,ENABLED"
  setclrfld.long 0x00 12. 0x04 12. 0x08 12. "  Data " "0,1"
  setclrfld.long 0x0C 12. 0x14 12. 0x10 12. "  Dir " "out,in "
  setclrfld.long 0x24 12. 0x28 12. 0x2C 12. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 12. 0x34 12. 0x38 12. "  PullType " "down,up"
  setclrfld.long 0x3C 12. 0x40 12. 0x44 12. "  Keep " "off,ON"
  setclrfld.long 0x48 12. 0x4C 12. 0x50 12. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 11. 0x1C 11. 0x20 11. "  11  " "disabled,ENABLED"
  setclrfld.long 0x00 11. 0x04 11. 0x08 11. "  Data " "0,1"
  setclrfld.long 0x0C 11. 0x14 11. 0x10 11. "  Dir " "out,in "
  setclrfld.long 0x24 11. 0x28 11. 0x2C 11. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 11. 0x34 11. 0x38 11. "  PullType " "down,up"
  setclrfld.long 0x3C 11. 0x40 11. 0x44 11. "  Keep " "off,ON"
  setclrfld.long 0x48 11. 0x4C 11. 0x50 11. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18 10. 0x1C 10. 0x20 10. "  10  " "disabled,ENABLED"
  setclrfld.long 0x00 10. 0x04 10. 0x08 10. "  Data " "0,1"
  setclrfld.long 0x0C 10. 0x14 10. 0x10 10. "  Dir " "out,in "
  setclrfld.long 0x24 10. 0x28 10. 0x2C 10. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30 10. 0x34 10. 0x38 10. "  PullType " "down,up"
  setclrfld.long 0x3C 10. 0x40 10. 0x44 10. "  Keep " "off,ON"
  setclrfld.long 0x48 10. 0x4C 10. 0x50 10. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18  9. 0x1C  9. 0x20  9. "   9  " "disabled,ENABLED"
  setclrfld.long 0x00  9. 0x04  9. 0x08  9. "  Data " "0,1"
  setclrfld.long 0x0C  9. 0x14  9. 0x10  9. "  Dir " "out,in "
  setclrfld.long 0x24  9. 0x28  9. 0x2C  9. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30  9. 0x34  9. 0x38  9. "  PullType " "down,up"
  setclrfld.long 0x3C  9. 0x40  9. 0x44  9. "  Keep " "off,ON"
  setclrfld.long 0x48  9. 0x4C  9. 0x50  9. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18  8. 0x1C  8. 0x20  8. "   8  " "disabled,ENABLED"
  setclrfld.long 0x00  8. 0x04  8. 0x08  8. "  Data " "0,1"
  setclrfld.long 0x0C  8. 0x14  8. 0x10  8. "  Dir " "out,in "
  setclrfld.long 0x24  8. 0x28  8. 0x2C  8. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30  8. 0x34  8. 0x38  8. "  PullType " "down,up"
  setclrfld.long 0x3C  8. 0x40  8. 0x44  8. "  Keep " "off,ON"
  setclrfld.long 0x48  8. 0x4C  8. 0x50  8. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18  7. 0x1C  7. 0x20  7. "   7  " "disabled,ENABLED"
  setclrfld.long 0x00  7. 0x04  7. 0x08  7. "  Data " "0,1"
  setclrfld.long 0x0C  7. 0x14  7. 0x10  7. "  Dir " "out,in "
  setclrfld.long 0x24  7. 0x28  7. 0x2C  7. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30  7. 0x34  7. 0x38  7. "  PullType " "down,up"
  setclrfld.long 0x3C  7. 0x40  7. 0x44  7. "  Keep " "off,ON"
  setclrfld.long 0x48  7. 0x4C  7. 0x50  7. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18  6. 0x1C  6. 0x20  6. "   6  " "disabled,ENABLED"
  setclrfld.long 0x00  6. 0x04  6. 0x08  6. "  Data " "0,1"
  setclrfld.long 0x0C  6. 0x14  6. 0x10  6. "  Dir " "out,in "
  setclrfld.long 0x24  6. 0x28  6. 0x2C  6. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30  6. 0x34  6. 0x38  6. "  PullType " "down,up"
  setclrfld.long 0x3C  6. 0x40  6. 0x44  6. "  Keep " "off,ON"
  setclrfld.long 0x48  6. 0x4C  6. 0x50  6. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18  5. 0x1C  5. 0x20  5. "   5  " "disabled,ENABLED"
  setclrfld.long 0x00  5. 0x04  5. 0x08  5. "  Data " "0,1"
  setclrfld.long 0x0C  5. 0x14  5. 0x10  5. "  Dir " "out,in "
  setclrfld.long 0x24  5. 0x28  5. 0x2C  5. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30  5. 0x34  5. 0x38  5. "  PullType " "down,up"
  setclrfld.long 0x3C  5. 0x40  5. 0x44  5. "  Keep " "off,ON"
  setclrfld.long 0x48  5. 0x4C  5. 0x50  5. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18  4. 0x1C  4. 0x20  4. "   4  " "disabled,ENABLED"
  setclrfld.long 0x00  4. 0x04  4. 0x08  4. "  Data " "0,1"
  setclrfld.long 0x0C  4. 0x14  4. 0x10  4. "  Dir " "out,in "
  setclrfld.long 0x24  4. 0x28  4. 0x2C  4. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30  4. 0x34  4. 0x38  4. "  PullType " "down,up"
  setclrfld.long 0x3C  4. 0x40  4. 0x44  4. "  Keep " "off,ON"
  setclrfld.long 0x48  4. 0x4C  4. 0x50  4. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18  3. 0x1C  3. 0x20  3. "   3  " "disabled,ENABLED"
  setclrfld.long 0x00  3. 0x04  3. 0x08  3. "  Data " "0,1"
  setclrfld.long 0x0C  3. 0x14  3. 0x10  3. "  Dir " "out,in "
  setclrfld.long 0x24  3. 0x28  3. 0x2C  3. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30  3. 0x34  3. 0x38  3. "  PullType " "down,up"
  setclrfld.long 0x3C  3. 0x40  3. 0x44  3. "  Keep " "off,ON"
  setclrfld.long 0x48  3. 0x4C  3. 0x50  3. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18  2. 0x1C  2. 0x20  2. "   2  " "disabled,ENABLED"
  setclrfld.long 0x00  2. 0x04  2. 0x08  2. "  Data " "0,1"
  setclrfld.long 0x0C  2. 0x14  2. 0x10  2. "  Dir " "out,in "
  setclrfld.long 0x24  2. 0x28  2. 0x2C  2. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30  2. 0x34  2. 0x38  2. "  PullType " "down,up"
  setclrfld.long 0x3C  2. 0x40  2. 0x44  2. "  Keep " "off,ON"
  setclrfld.long 0x48  2. 0x4C  2. 0x50  2. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18  1. 0x1C  1. 0x20  1. "   1  " "disabled,ENABLED"
  setclrfld.long 0x00  1. 0x04  1. 0x08  1. "  Data " "0,1"
  setclrfld.long 0x0C  1. 0x14  1. 0x10  1. "  Dir " "out,in "
  setclrfld.long 0x24  1. 0x28  1. 0x2C  1. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30  1. 0x34  1. 0x38  1. "  PullType " "down,up"
  setclrfld.long 0x3C  1. 0x40  1. 0x44  1. "  Keep " "off,ON"
  setclrfld.long 0x48  1. 0x4C  1. 0x50  1. "  OpenDrain " "push-pull,open drain"
  textline ""
  setclrfld.long 0x18  0. 0x1C  0. 0x20  0. "   0  " "disabled,ENABLED"
  setclrfld.long 0x00  0. 0x04  0. 0x08  0. "  Data " "0,1"
  setclrfld.long 0x0C  0. 0x14  0. 0x10  0. "  Dir " "out,in "
  setclrfld.long 0x24  0. 0x28  0. 0x2C  0. "  PullCtrl " "disable,enable"
  setclrfld.long 0x30  0. 0x34  0. 0x38  0. "  PullType " "down,up"
  setclrfld.long 0x3C  0. 0x40  0. 0x44  0. "  Keep " "off,ON"
  setclrfld.long 0x48  0. 0x4C  0. 0x50  0. "  OpenDrain " "push-pull,open drain"
  textline ""
  line.long 0x54 "  RAW IN"
tree.end
tree "Port B"
group 0x060--0x0BF
  copy
tree.end
tree "Port C"
group 0x0C0--0x11F
  copy
tree.end
tree "Port D"
group 0x120--0x17F
  copy
tree.end
tree "Port E"
group 0x180--0x1DF
  copy
tree.end
tree "Port F"
group 0x1E0--0x23F
  copy
tree.end
tree "Port G"
group 0x240--0x29F
  copy
tree.end

textline ""
group 0x2A0--0x2A3
  line.long 0 "EXTINT_CFG"
  textline ""
  bitfld.long 0 30.--31. "    EXTINT15 " "low level,high level,falling edge,rising edge"
  bitfld.long 0 28.--29. "    EXTINT14 " "low level,high level,falling edge,rising edge"
  bitfld.long 0 26.--27. "    EXTINT13 " "low level,high level,falling edge,rising edge"
  bitfld.long 0 24.--25. "    EXTINT12 " "low level,high level,falling edge,rising edge"
  textline ""
  bitfld.long 0 22.--23. "    EXTINT11 " "low level,high level,falling edge,rising edge"
  bitfld.long 0 20.--21. "    EXTINT10 " "low level,high level,falling edge,rising edge"
  bitfld.long 0 18.--19. "    EXTINT9  " "low level,high level,falling edge,rising edge"
  bitfld.long 0 16.--17. "    EXTINT8  " "low level,high level,falling edge,rising edge"
  textline ""
  bitfld.long 0 14.--15. "    EXTINT7  " "low level,high level,falling edge,rising edge"
  bitfld.long 0 12.--13. "    EXTINT6  " "low level,high level,falling edge,rising edge"
  bitfld.long 0 10.--11. "    EXTINT5  " "low level,high level,falling edge,rising edge"
  bitfld.long 0  8.--9.  "    EXTINT4  " "low level,high level,falling edge,rising edge"
  textline ""
  bitfld.long 0  6.--7.  "    EXTINT3  " "low level,high level,falling edge,rising edge"
  bitfld.long 0  4.--5.  "    EXTINT2  " "low level,high level,falling edge,rising edge"
  bitfld.long 0  2.--3.  "    EXTINT1  " "low level,high level,falling edge,rising edge"
  bitfld.long 0  0.--1.  "    EXTINT0  " "low level,high level,falling edge,rising edge"
rgroup 0x2A4--0x2A7
  line.long 0 "EXTINT_EDGE"
rgroup 0x2A8--0x2AB
  line.long 0 "EXTINT_STAT"
wgroup 0x2AC--0x2AF
  hide.long 0 "EXTINT_CLEAR"

group 0x2B0--0x2B3
  line.long 0 "KPINT_CFG"
  hexmask.long.byte 0  8.--15. 1 "    KPINT_ROW_EN "
  hexmask.long.byte 0  0.--7.  1 "    KPINT_COL_EN "
rgroup 0x2B4--0x2B7
  line.long 0 "KPINT_ROW"
group 0x2B8--0x2BB
  line.long 0 "KPINT_COL"
tree.end

;=====================================================
tree "I2C      - I2C Bus Interface"
;=====================================================
;-----------------------------------------------------
tree "I2C1"
;-----------------------------------------------------
base a:0x06200000
wgroup 0x000--0x001
 hide.word 0 "IICRXTX, Receive/Transmit FIFO"
rgroup 0x004--0x005
 line.word 0 "IICSTS, Status Register"
  textline ""
  bitfld.word 0 14. "    MAST       ," " slave, master "
  textline ""
  bitfld.word 0 13. "    TFES       ," " slave TX FIFO not empty, slave TX FIFO empty "
  textline ""
  bitfld.word 0 12. "    TFFS       ," " slave TX FIFO not full, slave TX FIFO full "
  textline ""
  bitfld.word 0 11. "    TFE        ," " TX FIFO not empty, TX FIFO empty "
  textline ""
  bitfld.word 0 10. "    TFF        ," " TX FIFO not full, TX FIFO full "
  textline ""
  bitfld.word 0  9. "    RFE        ," " RX FIFO not empty, RX FIFO empty "
  textline ""
  bitfld.word 0  8. "    RFF        ," " RX FIFO not full, RX FIFO full "
  textline ""
  bitfld.word 0  7. "    SDA        ," " 0, 1 "
  textline ""
  bitfld.word 0  6. "    SCL        ," " 0, 1 "
  textline ""
  bitfld.word 0  5. "    ACTIVE     ," " not busy, busy "
  textline ""
  bitfld.word 0  4. "    DRSI       ," " slave transmitter does not need data, slave transmitter needs data "
  textline ""
  bitfld.word 0  3. "    DRMI       ," " master transmitter does not need data, master transmitter needs data "
  textline ""
  bitfld.word 0  2. "    NAI        ," " ack received, ack not received "
  textline ""
  bitfld.word 0  1. "    AFI        ," " no arbitration failure, arbitration failure "
  textline ""
  bitfld.word 0  0. "    TDI        ," " transaction not completed, transaction completed "
group 0x008--0x009
 line.word 0 "IICCTL, Control Register"
  textline ""
  bitfld.word 0 11. "    STOPIE     ," " disable stop interrupt, enable stop interrupt "
  textline ""
  bitfld.word 0 10. "    TFFSIE     ," " disable tffs interrupt, enable tffs interrupt "
  textline ""
  bitfld.word 0  8. "    SR         ," " no reset, reset the I2C bus "
  textline ""
  bitfld.word 0  7. "    TFFIE      ," " disable tff interrupt, enable tff interrupt "
  textline ""
  bitfld.word 0  6. "    RFDAIE     ," " disable rfe interrupt, enable rfe interrupt "
  textline ""
  bitfld.word 0  5. "    DAIE       ," " disable rff interrupt, enable rff interrupt "
  textline ""
  bitfld.word 0  4. "    DRSIE      ," " disable drs interrupt, enable drs interrupt "
  textline ""
  bitfld.word 0  3. "    DRMIE      ," " disable drm interrupt, enable drm interrupt "
  textline ""
  bitfld.word 0  2. "    NAIE       ," " disable nai interrupt, enable nai interrupt "
  textline ""
  bitfld.word 0  1. "    AFIE       ," " disable afi interrupt, enable afi interrupt "
  textline ""
  bitfld.word 0  0. "    TDIE       ," " disable tdi interrupt, enable tdi interrupt "
group 0x00C--0x00D
 line.word 0 "IICCLKHI, Clock High Time Control Register"
group 0x010--0x011
 line.word 0 "IICCLKLO, Clock Low Time Control Register"
group 0x014--0x017
 line.word 0 "IICADDR, Slave Address Register"
wgroup 0x018--0x01B
 line.word 0 "IICHOLDDAT, Data Hold Time Control Register"
group 0x028--0x02B
 hide.word 0 "IICTXS, Transmit FIFO in Slave Mode"
tree.end

;-----------------------------------------------------
tree "I2C2"
;-----------------------------------------------------
base a:0x06300000
wgroup 0x000--0x001
 hide.word 0 "IICRXTX, Receive/Transmit FIFO"
rgroup 0x004--0x005
 line.word 0 "IICSTS, Status Register"
  textline ""
  bitfld.word 0 14. "    MAST       ," " slave, master "
  textline ""
  bitfld.word 0 13. "    TFES       ," " slave TX FIFO not empty, slave TX FIFO empty "
  textline ""
  bitfld.word 0 12. "    TFFS       ," " slave TX FIFO not full, slave TX FIFO full "
  textline ""
  bitfld.word 0 11. "    TFE        ," " TX FIFO not empty, TX FIFO empty "
  textline ""
  bitfld.word 0 10. "    TFF        ," " TX FIFO not full, TX FIFO full "
  textline ""
  bitfld.word 0  9. "    RFE        ," " RX FIFO not empty, RX FIFO empty "
  textline ""
  bitfld.word 0  8. "    RFF        ," " RX FIFO not full, RX FIFO full "
  textline ""
  bitfld.word 0  7. "    SDA        ," " 0, 1 "
  textline ""
  bitfld.word 0  6. "    SCL        ," " 0, 1 "
  textline ""
  bitfld.word 0  5. "    ACTIVE     ," " not busy, busy "
  textline ""
  bitfld.word 0  4. "    DRSI       ," " slave transmitter does not need data, slave transmitter needs data "
  textline ""
  bitfld.word 0  3. "    DRMI       ," " master transmitter does not need data, master transmitter needs data "
  textline ""
  bitfld.word 0  2. "    NAI        ," " ack received, ack not received "
  textline ""
  bitfld.word 0  1. "    AFI        ," " no arbitration failure, arbitration failure "
  textline ""
  bitfld.word 0  0. "    TDI        ," " transaction not completed, transaction completed "
group 0x008--0x009
 line.word 0 "IICCTL, Control Register"
  textline ""
  bitfld.word 0 11. "    STOPIE     ," " disable stop interrupt, enable stop interrupt "
  textline ""
  bitfld.word 0 10. "    TFFSIE     ," " disable tffs interrupt, enable tffs interrupt "
  textline ""
  bitfld.word 0  8. "    SR         ," " no reset, reset the I2C bus "
  textline ""
  bitfld.word 0  7. "    TFFIE      ," " disable tff interrupt, enable tff interrupt "
  textline ""
  bitfld.word 0  6. "    RFDAIE     ," " disable rfe interrupt, enable rfe interrupt "
  textline ""
  bitfld.word 0  5. "    DAIE       ," " disable rff interrupt, enable rff interrupt "
  textline ""
  bitfld.word 0  4. "    DRSIE      ," " disable drs interrupt, enable drs interrupt "
  textline ""
  bitfld.word 0  3. "    DRMIE      ," " disable drm interrupt, enable drm interrupt "
  textline ""
  bitfld.word 0  2. "    NAIE       ," " disable nai interrupt, enable nai interrupt "
  textline ""
  bitfld.word 0  1. "    AFIE       ," " disable afi interrupt, enable afi interrupt "
  textline ""
  bitfld.word 0  0. "    TDIE       ," " disable tdi interrupt, enable tdi interrupt "
group 0x00C--0x00D
 line.word 0 "IICCLKHI, Clock High Time Control Register"
group 0x010--0x011
 line.word 0 "IICCLKLO, Clock Low Time Control Register"
group 0x014--0x017
 line.word 0 "IICADDR, Slave Address Register"
wgroup 0x018--0x01B
 line.word 0 "IICHOLDDAT, Data Hold Time Control Register"
group 0x028--0x02B
 hide.word 0 "IICTXS, Transmit FIFO in Slave Mode"
tree.end
tree.end

;=====================================================
tree "IRCU     - IR Remote Control Unit"
;=====================================================
base a:0x05500000
group 0x000--0x003
 line.long 0 "IRCU_TX_EN, TX enable"
group 0x004--0x007
 line.long 0 "IRCU_TX_FRM, TX frame"
group 0x008--0x00B
 line.long 0 "IRCU_TXFRM_DUR, TX frame duration"
  textline ""
  bitfld.long 0  0.--8.  "    LDR_AGC_MARK_DUR      ," "    "
  textline ""
  bitfld.long 0 12.--19. "    LDR_AGC_SPACE_DUR     ," "    "
  textline ""
  bitfld.long 0 24.--28. "    FRM_END_DUR           ," "    "
group 0x00C--0x00F
 line.long 0 "IRCU_RPT_CODED, Repeat code transmit duration"
  textline ""
  bitfld.long 0  0.--8.  "    RPT_AGC_MARK_DUR      ," "    "
  textline ""
  bitfld.long 0 12.--19. "    RPT_AGC_SPACE_DUR     ," "    "
  textline ""
  bitfld.long 0 24.--28. "    RPT_END_DUR           ," "    "
group 0x010--0x013
 line.long 0 "IRCU_RPT_DLYD, Repeat delay duration"
group 0x014--0x017
 line.long 0 "IRCU_CFG, Configuration"
  textline ""
  bitfld.long 0  0.      "    EN_RPT_CODE           ," "    "
  textline ""
  bitfld.long 0  1.      "    EN_RPT_FRM            ," "    "
  textline ""
  bitfld.long 0  4.--7.  "    TX_FRM_RPT            ," "    "
  textline ""
  bitfld.long 0  8.      "    TX_FRM_ORDER          ," "    "
  textline ""
  bitfld.long 0  9.      "    ACTIVE_LEVEL          ," "    "
  textline ""
  bitfld.long 0 12.--16. "    FRM_LNGTH             ," "    "
  textline ""
  bitfld.long 0 17.      "    LOGIC_1_TX_ORDER      ," "    "
  textline ""
  bitfld.long 0 18.      "    LOGIC_0_TX_ORDER      ," "    "
  textline ""
  bitfld.long 0 19.      "    DIS_TX_END            ," "    "
group 0x018--0x01B
 line.long 0 "IRCU_TX_DATD, TX data duration"
  textline ""
  bitfld.long 0  0.--5.  "    LOGIC_0_MARK_DUR      ," "    "
  textline ""
  bitfld.long 0  8.--13. "    LOGIC_0_SPACE_DUR     ," "    "
  textline ""
  bitfld.long 0 16.--21. "    LOGIC_1_MARK_DUR      ," "    "
  textline ""
  bitfld.long 0 24.--30. "    LOGIC_1_SPACE_DUR     ," "    "
rgroup 0x01C--0x01F
 line.long 0 "IRCU_STAT, Status"
group 0x020--0x023
 line.long 0 "IRCU_CONF, Baud rate configuration"
rgroup 0x024--0x027
 line.long 0 "IRCU_STAT_DBG1, Status debug 1"
  textline ""
  bitfld.long 0  0.--12. "    TX_RPT_DLY_CNTR       ," "    "
  textline ""
  bitfld.long 0 16.--19. "    TX_FRM_RPT_CNTR       ," "    "
rgroup 0x028--0x02B
 line.long 0 "IRCU_STAT_DBG2, Status debug 2"
  textline ""
  bitfld.long 0  0.--1.  "    TX_FSM_STATUS         ," "    "
  textline ""
  bitfld.long 0  4.--12. "    MARK_DUR_CNTR         ," "    "
  textline ""
  bitfld.long 0 16.--23. "    SPACE_DUR_CNTR        ," "    "
  textline ""
  bitfld.long 0 24.--29. "    BITS2TX_CNTR          ," "    "
tree.end

;=====================================================
tree "LCDC     - LCD Controller"
;=====================================================
base a:0x06b00000
group 0x000--0x003
 line.long 0 "INTR, Interrupt Register"
  bitfld.long 0 0. "ARMINT ,Interrupt to ARM" "no,yes"
group 0x004--0x007
 line.long 0 "INTSR, Interrupt Source Register"
  bitfld.long 0 5.  "CPUTYPERD ,CPU-Type Read Done" "no,yes"
  bitfld.long 0 4. " CMDFIFOE ,Command FIFO Empty" "no,yes"
  bitfld.long 0 3. " STNRDERR ,Display FIFO Under-run in STN mode" "no,yes"
  bitfld.long 0 2. " TFTRDERR ,Display FIFO Under-run in TFT/CCIR656 mode" "no,yes"
  bitfld.long 0 1. " FRMEND ,Frame Display Done" "no,yes"
  bitfld.long 0 0. " FRMSTR ,New Frame Start" "no,yes"
group 0x008--0x00B
 line.long 0 "INTER,"
group 0x010--0x013
 line.long 0 "LCDCCR,"
group 0x020--0x023
 line.long 0 "INTMR,"
group 0x024--0x027
 line.long 0 "DISPCR,"
group 0x028--0x02B
 line.long 0 "OSDMCR,"
group 0x040--0x043
 line.long 0 "INDTR,"
group 0x044--0x047
 line.long 0 "INDXSR,"
group 0x048--0x04B
 line.long 0 "INDYSR,"
group 0x050--0x053
 line.long 0 "DISPXSPOSR,"
group 0x054--0x057
 line.long 0 "DISPXEPOSR,"
group 0x060--0x063
 line.long 0 "DISPYSPOS1R,"
group 0x064--0x067
 line.long 0 "DISPYEPOS1R,"
group 0x068--0x06B
 line.long 0 "DISPYSPOS2R,"
group 0x06c--0x06f
 line.long 0 "DISPYEPOS2R,"
group 0x090--0x093
 line.long 0 "DISPIDXR,"
group 0x0A0--0x0A3
 line.long 0 "MSBAHBA0R,"
group 0x0A4--0x0A7
 line.long 0 "LSBAHBA0R,"
group 0x0A8--0x0AB
 line.long 0 "OFFAR0,"
group 0x0B0--0x0B3
 line.long 0 "MSBAHBA1R,"
group 0x0B4--0x0B7
 line.long 0 "LSBAHBA1R,"
group 0x0B8--0x0BB
 line.long 0 "OFFAR1,"
group 0x100--0x103
 line.long 0 "PALR0,"
group 0x104--0x107
 line.long 0 "PALR1,"
group 0x108--0x10B
 line.long 0 "PALR2,"
group 0x10C--0x10F
 line.long 0 "PALR3,"
group 0x140--0x143
 line.long 0 "BACKCPR,"
group 0x150--0x153
 line.long 0 "RBCR,"
group 0x154--0x157
 line.long 0 "GBCR,"
group 0x158--0x15B
 line.long 0 "BBCR,"
group 0x160--0x163
 line.long 0 "GC0R,"
group 0x164--0x167
 line.long 0 "GC1R,"
group 0x168--0x16B
 line.long 0 "GC2R,"
group 0x16C--0x16F
 line.long 0 "GC3R,"
group 0x170--0x173
 line.long 0 "GC4R,"
group 0x174--0x177
 line.long 0 "GC5R,"
group 0x178--0x17B
 line.long 0 "GC6R,"
group 0x17C--0x17F
 line.long 0 "GC7R,"
group 0x180--0x183
 line.long 0 "GC8R,"
group 0x184--0x187
 line.long 0 "GC9R,"
group 0x188--0x18B
 line.long 0 "GC10R,"
group 0x18C--0x18F
 line.long 0 "GC11R,"
group 0x190--0x193
 line.long 0 "GC12R,"
group 0x194--0x197
 line.long 0 "GC13R,"
group 0x198--0x19B
 line.long 0 "GC14R,"
group 0x19C--0x19F
 line.long 0 "GC15R,"
group 0x1A0--0x1A3
 line.long 0 "GC16R,"
group 0x1A4--0x1A7
 line.long 0 "GCER,"
group 0x200--0x203
 line.long 0 "YCLPCR,"
group 0x204--0x207
 line.long 0 "CCLPCR,"
group 0x208--0x20B
 line.long 0 "CLPER,"
group 0x240--0x243
 line.long 0 "DISPIR,"
group 0x250--0x253
 line.long 0 "PANCSR,"
group 0x270--0x273
 line.long 0 "VSTR,"
group 0x274--0x277
 line.long 0 "VFTR,"
group 0x278--0x27B
 line.long 0 "VATR,"
group 0x27C--0x27F
 line.long 0 "VETR,"
group 0x280--0x283
 line.long 0 "HSTR,"
group 0x284--0x287
 line.long 0 "HFTR,"
group 0x288--0x28B
 line.long 0 "HADSTR,"
group 0x28C--0x28F
 line.long 0 "HAPWR,"
group 0x290--0x293
 line.long 0 "HETR,"
group 0x2A8--0x2AB
 line.long 0 "CTLTR0,"
group 0x2C0--0x2C3
 line.long 0 "CMDFSR,"
group 0x2C4--0x2C7
 line.long 0 "CMDAR,"
group 0x2C8--0x2CB
 line.long 0 "TXDR,"
group 0x2CC--0x2CF
 line.long 0 "RXDR,"
group 0x310--0x313
 line.long 0 "GP0A_H_HI,"
group 0x314--0x317
 line.long 0 "GP0A_V_ST,"
group 0x318--0x31B
 line.long 0 "GP0A_H_LO,"
group 0x31C--0x31F
 line.long 0 "GP0A_V_END,"
group 0x320--0x323
 line.long 0 "GP0ACNTR,"
group 0x330--0x333
 line.long 0 "GP0B_H_HI,"
group 0x334--0x337
 line.long 0 "GP0B_V_ST,"
group 0x338--0x33B
 line.long 0 "GP0B_H_LO,"
group 0x33C--0x33F
 line.long 0 "GP0B_V_END,"
group 0x340--0x343
 line.long 0 "GP0BCNTR,"
group 0x350--0x353
 line.long 0 "GP1A_H_HI,"
group 0x354--0x357
 line.long 0 "GP1A_V_ST,"
group 0x358--0x35B
 line.long 0 "GP1A_H_LO,"
group 0x35C--0x35F
 line.long 0 "GP1A_V_END,"
group 0x360--0x363
 line.long 0 "GP1ACNTR,"
group 0x370--0x373
 line.long 0 "GP1B_H_HI,"
group 0x374--0x377
 line.long 0 "GP1B_V_ST,"
group 0x378--0x37B
 line.long 0 "GP1B_H_LO,"
group 0x37C--0x37F
 line.long 0 "GP1B_V_END,"
group 0x380--0x383
 line.long 0 "GP1BCNTR,"
group 0x390--0x393
 line.long 0 "GP2_H_HI,"
group 0x394--0x397
 line.long 0 "GP2_V_ST,"
group 0x398--0x39B
 line.long 0 "GP2_H_LO,"
group 0x39C--0x39F
 line.long 0 "GP2_V_END,"
group 0x3A0--0x3A3
 line.long 0 "GP2_H_EX,"
group 0x3A4--0x3A7
 line.long 0 "GP2_V_EX,"
group 0x3A8--0x3AB
 line.long 0 "GP2CNTR,"
group 0x3B0--0x3B3
 line.long 0 "GP3_H_HI,"
group 0x3B4--0x3B7
 line.long 0 "GP3_V_ST,"
group 0x3B8--0x3BB
 line.long 0 "GP3_H_LO,"
group 0x3BC--0x3BF
 line.long 0 "GP3_V_END,"
group 0x3C0--0x3C3
 line.long 0 "GP3_H_EX,"
group 0x3C4--0x3C7
 line.long 0 "GP3_V_EX,"
group 0x3C8--0x3CB
 line.long 0 "GP3CNTR,"
group 0x3D0--0x3D3
 line.long 0 "GP4_H_HI,"
group 0x3D4--0x3D7
 line.long 0 "GP4_V_ST,"
group 0x3D8--0x3DB
 line.long 0 "GP4_H_LO,"
group 0x3DC--0x3DF
 line.long 0 "GP4_V_END,"
group 0x3D0--0x3D3
 line.long 0 "GP4CNTR,"
group 0x3F0--0x3F3
 line.long 0 "GP5_H_HI,"
group 0x3F4--0x3F7
 line.long 0 "GP5_V_ST,"
group 0x3F8--0x3FB
 line.long 0 "GP5_H_LO,"
group 0x3FC--0x3FF
 line.long 0 "GP5_V_END,"
group 0x400--0x403
 line.long 0 "GP5CNTR,"
group 0x410--0x413
 line.long 0 "GP6_H_HI,"
group 0x414--0x417
 line.long 0 "GP6_V_ST,"
group 0x418--0x41B
 line.long 0 "GP6_H_LO,"
group 0x41C--0x41F
 line.long 0 "GP6_V_END,"
group 0x420--0x423
 line.long 0 "GP6CNTR,"
group 0x430--0x433
 line.long 0 "GP7_H_HI,"
group 0x434--0x437
 line.long 0 "GP7_V_ST,"
group 0x438--0x43B
 line.long 0 "GP7_H_LO,"
group 0x43C--0x43F
 line.long 0 "GP7_V_END,"
group 0x440--0x443
 line.long 0 "GP7CNTR,"
group 0x450--0x453
 line.long 0 "GP8A_H_HI,"
group 0x454--0x457
 line.long 0 "GP8A_V_ST,"
group 0x458--0x45B
 line.long 0 "GP8A_H_LO,"
group 0x45C--0x45F
 line.long 0 "GP8A_V_END,"
group 0x460--0x463
 line.long 0 "GP8ACNTR,"
group 0x470--0x473
 line.long 0 "GP8B_H_HI,"
group 0x474--0x477
 line.long 0 "GP8B_V_ST,"
group 0x478--0x47B
 line.long 0 "GP8B_H_LO,"
group 0x47C--0x47F
 line.long 0 "GP8B_V_END,"
group 0x480--0x483
 line.long 0 "GP8BCNTR,"
group 0x490--0x493
 line.long 0 "GP_HMAXR,"
group 0x494--0x497
 line.long 0 "GP_VMAXR,"
group 0x4A0--0x4A3
 line.long 0 "GPSELR,"
group 0x4A4--0x4A7
 line.long 0 "GP_FMR,"
group 0x4D0--0x4D3
 line.long 0 "PARUP,"
group 0x4D4--0x4D7
 line.long 0 "CDISPUPR,"
group 0x4F0--0x4F3
 line.long 0 "ISTAR0,"
group 0x4F4--0x4F7
 line.long 0 "ISTAR1,"
group 0x4F8--0x4FB
 line.long 0 "ISTAR2,"
group 0x4FC--0x4FF
 line.long 0 "ISTAR3,"
group 0x500--0x503
 line.long 0 "ISTAR4,"
group 0x528--0x52B
 line.long 0 "CMDFIFOR0,"
group 0x52C--0x52F
 line.long 0 "CMDFIFOR1,"
group 0x530--0x533
 line.long 0 "CMDFIFOR2,"
group 0x534--0x537
 line.long 0 "CMDFIFOR3,"
group 0x538--0x53B
 line.long 0 "CMDFIFOR4,"
group 0x53C--0x53F
 line.long 0 "CMDFIFOR5,"
group 0x540--0x543
 line.long 0 "CMDFIFOR6,"
group 0x544--0x547
 line.long 0 "CMDFIFOR7,"
group 0x548--0x54B
 line.long 0 "CMDFIFOR8,"
group 0x54C--0x54F
 line.long 0 "CMDFIFOR9,"
group 0x550--0x553
 line.long 0 "CMDFIFOR10,"
group 0x554--0x557
 line.long 0 "CMDFIFOR11,"
group 0x558--0x55B
 line.long 0 "RSCMDR,"
group 0x55C--0x55F
 line.long 0 "RWCMDR,"
group 0x560--0x563
 line.long 0 "LCMDR,"
tree.end

;=====================================================
tree "OSDM     - On Screen Display Manager"
;=====================================================
base a:0x06a00000
group 0x000--0x003
 line.long 0 "OSDM_CONFIG"
rgroup 0x004--0x007
 line.long 0 "INTR_STATUS"
group 0x008--0x00B
 line.long 0 "INTR_MASK"
rgroup 0x00C--0x00F
 line.long 0 "INTR_CAUSE"
group 0x010--0x013
 line.long 0 "INTR_CLEAR"
rgroup 0x014--0x017
 line.long 0 "DMA_ERROR"
group 0x018--0x01B
 line.long 0 "DISPLAY_DIM"
group 0x01C--0x01F
 line.long 0 "DISPLAY_BGC"
group 0x020--0x023
 line.long 0 "VIDEO0_CONFIG"
group 0x024--0x027
 line.long 0 "VIDEO0_POS"
group 0x028--0x02B
 line.long 0 "VIDEO0_DIM"
group 0x02C--0x02F
 line.long 0 "VIDEO0_BCSH"
group 0x030--0x033
 line.long 0 "VIDEO0_TPOS"
group 0x034--0x037
 line.long 0 "VIDEO0_TDIM"
group 0x038--0x03B
 line.long 0 "VIDEO0_TPIXEL"
group 0x03C--0x03F
 line.long 0 "VIDEO0_ALCK"
group 0x040--0x043
 line.long 0 "VIDEO0_YUVLIM"
group 0x050--0x053
 line.long 0 "VIDEO1_CONFIG"
group 0x054--0x057
 line.long 0 "VIDEO1_POS"
group 0x058--0x05B
 line.long 0 "VIDEO1_DIM"
group 0x05C--0x05F
 line.long 0 "VIDEO1_BCSH"
group 0x060--0x063
 line.long 0 "VIDEO1_TPOS"
group 0x064--0x067
 line.long 0 "VIDEO1_TDIM"
group 0x068--0x06B
 line.long 0 "VIDEO1_TPIXEL"
group 0x06C--0x06F
 line.long 0 "VIDEO1_ALCK"
group 0x070--0x073
 line.long 0 "VIDEO1_YUVLIM"
group 0x080--0x083
 line.long 0 "OSD0_CONFIG"
group 0x084--0x087
 line.long 0 "OSD0_POS"
group 0x088--0x08B
 line.long 0 "OSD0_DIM"
group 0x08C--0x08F
 line.long 0 "OSD0_TPOS"
group 0x090--0x093
 line.long 0 "OSD0_TDIM"
group 0x094--0x097
 line.long 0 "OSD0_TPIXEL"
group 0x098--0x09B
 line.long 0 "OSD0_ALCK"
group 0x0A0--0x0A3
 line.long 0 "OSD1_CONFIG"
group 0x0A4--0x0A7
 line.long 0 "OSD1_POS"
group 0x0A8--0x0AB
 line.long 0 "OSD1_DIM"
group 0x0AC--0x0AF
 line.long 0 "OSD1_TPOS"
group 0x0B0--0x0B3
 line.long 0 "OSD1_TDIM"
group 0x0B4--0x0B7
 line.long 0 "OSD1_TPIXEL"
group 0x0B8--0x0BB
 line.long 0 "OSD1_ALCK"
group 0x0C0--0x0C3
 line.long 0 "OSD2_CONFIG"
group 0x0C4--0x0C7
 line.long 0 "OSD2_POS"
group 0x0C8--0x0CB
 line.long 0 "OSD2_DIM"
group 0x0CC--0x0CF
 line.long 0 "OSD2_TPOS"
group 0x0D0--0x0D3
 line.long 0 "OSD2_TDIM"
group 0x0D4--0x0D7
 line.long 0 "OSD2_TPIXEL"
group 0x0D8--0x0DB
 line.long 0 "OSD2_ALCK"
group 0x100--0x103
 line.long 0 "DMA0_CONFIG"
group 0x104--0x107
 line.long 0 "DMA0_BADDR0"
group 0x108--0x10B
 line.long 0 "DMA0_BADDR1"
group 0x10C--0x10F
 line.long 0 "DMA0_STRIDE"
group 0x110--0x113
 line.long 0 "DMA0_BSIZE"
group 0x114--0x117
 line.long 0 "DMA0_BCOUNT"
group 0x120--0x123
 line.long 0 "DMA1_CONFIG"
group 0x124--0x127
 line.long 0 "DMA1_BADDR0"
group 0x128--0x12B
 line.long 0 "DMA1_BADDR1"
group 0x12C--0x12F
 line.long 0 "DMA1_STRIDE"
group 0x130--0x133
 line.long 0 "DMA1_BSIZE"
group 0x134--0x137
 line.long 0 "DMA1_BCOUNT"
group 0x138--0x13B
 line.long 0 "DMA1_TPOS"
group 0x13C--0x13F
 line.long 0 "DMA1_TDIM"
group 0x140--0x143
 line.long 0 "DMA2_CONFIG"
group 0x144--0x147
 line.long 0 "DMA2_BADDR0"
group 0x148--0x14B
 line.long 0 "DMA2_BADDR1"
group 0x14C--0x14F
 line.long 0 "DMA2_STRIDE"
group 0x150--0x153
 line.long 0 "DMA2_BSIZE"
group 0x154--0x157
 line.long 0 "DMA2_BCOUNT"
group 0x158--0x15B
 line.long 0 "DMA2_TPOS"
group 0x15C--0x15F
 line.long 0 "DMA2_TDIM"
group 0x160--0x163
 line.long 0 "DMA3_CONFIG"
group 0x164--0x167
 line.long 0 "DMA3_BADDR0"
group 0x168--0x16B
 line.long 0 "DMA3_BADDR1"
group 0x16C--0x16F
 line.long 0 "DMA3_STRIDE"
group 0x170--0x173
 line.long 0 "DMA3_BSIZE"
group 0x174--0x177
 line.long 0 "DMA3_BCOUNT"
group 0x178--0x17B
 line.long 0 "DMA3_TPOS"
group 0x17C--0x17F
 line.long 0 "DMA3_TDIM"
group 0x180--0x183
 line.long 0 "DMA4_CONFIG"
group 0x184--0x187
 line.long 0 "DMA4_BADDR0"
group 0x188--0x18B
 line.long 0 "DMA4_BADDR1"
group 0x18C--0x18F
 line.long 0 "DMA4_STRIDE"
group 0x190--0x193
 line.long 0 "DMA4_BSIZE"
group 0x194--0x197
 line.long 0 "DMA4_BCOUNT"
group 0x198--0x19B
 line.long 0 "DMA4_TPOS"
group 0x19C--0x19F
 line.long 0 "DMA4_TDIM"
group 0x1A0--0x1A3
 line.long 0 "DMA5_CONFIG"
group 0x1A4--0x1A7
 line.long 0 "DMA5_BADDR0"
group 0x1A8--0x1AB
 line.long 0 "DMA5_BADDR1"
group 0x1AC--0x1AF
 line.long 0 "DMA5_STRIDE"
group 0x1B0--0x1B3
 line.long 0 "DMA5_BSIZE"
group 0x1B4--0x1B7
 line.long 0 "DMA5_BCOUNT"
group 0x1B8--0x1BB
 line.long 0 "DMA5_TPOS"
group 0x1BC--0x1BF
 line.long 0 "DMA5_TDIM"
group 0x1C0--0x1C3
 line.long 0 "DMA6_CONFIG"
group 0x1C4--0x1C7
 line.long 0 "DMA6_BADDR0"
group 0x1C8--0x1CB
 line.long 0 "DMA6_BADDR1"
group 0x1CC--0x1CF
 line.long 0 "DMA6_STRIDE"
group 0x1D0--0x1D3
 line.long 0 "DMA6_BSIZE"
group 0x1D4--0x1D7
 line.long 0 "DMA6_BCOUNT"
group 0x1D8--0x1DB
 line.long 0 "DMA6_TPOS"
group 0x1DC--0x1DF
 line.long 0 "DMA6_TDIM"
group 0x1E0--0x1E3
 line.long 0 "DMA7_CONFIG"
group 0x1E4--0x1E7
 line.long 0 "DMA7_BADDR0"
group 0x1E8--0x1EB
 line.long 0 "DMA7_BADDR1"
group 0x1EC--0x1EF
 line.long 0 "DMA7_STRIDE"
group 0x1F0--0x1F3
 line.long 0 "DMA7_BSIZE"
group 0x1F4--0x1F7
 line.long 0 "DMA7_BCOUNT"
group 0x1F8--0x1FB
 line.long 0 "DMA7_TPOS"
group 0x1FC--0x1FF
 line.long 0 "DMA7_TDIM"
group 0x200--0x203
 line.long 0 "DMA8_CONFIG"
group 0x204--0x207
 line.long 0 "DMA8_BADDR0"
group 0x208--0x20B
 line.long 0 "DMA8_BADDR1"
group 0x20C--0x20F
 line.long 0 "DMA8_STRIDE"
group 0x210--0x213
 line.long 0 "DMA8_BSIZE"
group 0x214--0x217
 line.long 0 "DMA8_BCOUNT"
group 0x218--0x21B
 line.long 0 "DMA8_TPOS"
group 0x21C--0x21F
 line.long 0 "DMA8_TDIM"
group 0x220--0x223
 line.long 0 "DMA9_CONFIG"
group 0x224--0x227
 line.long 0 "DMA9_BADDR0"
group 0x228--0x22B
 line.long 0 "DMA9_BADDR1"
group 0x22C--0x22F
 line.long 0 "DMA9_STRIDE"
group 0x230--0x233
 line.long 0 "DMA9_BSIZE"
group 0x234--0x237
 line.long 0 "DMA9_BCOUNT"
group 0x238--0x23B
 line.long 0 "DMA9_TPOS"
group 0x23C--0x23F
 line.long 0 "DMA9_TDIM"
group 0x300--0x303
 line.long 0 "VIS_CONFIG"
rgroup 0x310--0x313
 line.long 0 "VIS_LAYER"
rgroup 0x320--0x323
 line.long 0 "VIS_DMA_ADDR"
rgroup 0x324--0x327
 line.long 0 "VIS_DMA_WPOS"
rgroup 0x328--0x32B
 line.long 0 "VIS_DMA_BPOS"
tree.end

;=====================================================
tree "PACP     - Peripheral Audio Co Processor"
;=====================================================
base a:0x06600000
group 0x000--0x003
 line.long 0 "PACP_CONFIG, Configuration Register"
  textline ""
  bitfld.long 0  0.--2.  "    PACP_MODE            ," " Null,Instruct Memory Access,Coefficient Memory Access,Reserved,X_MEM Access,Y_MEM Access,Single Sample,Functional   "
  textline ""
  bitfld.long 0  4.      "    GAIN_BYPASS          ," " 0,1 "
  textline ""
  bitfld.long 0  7.      "    STRB_OUT_EN          ," " 0,1 "
  textline ""
  bitfld.long 0  8.--9.  "    X_STACK_SIZE         ," " 0,4,8,16   "
  textline ""
  bitfld.long 0 12.--13. "    Y_STACK_SIZE         ," " 0,4,8,16   "
  textline ""
  bitfld.long 0 14.      "    PACP_EN              ," " 0,1 "
  textline ""
  bitfld.long 0 15.      "    FLUSH_IN_FIFO        ," " 0,1 "
  textline ""
  bitfld.long 0 16.      "    FLUSH_OUT_FIFO       ," " 0,1 "
  textline ""
  bitfld.long 0 17.      "    PACP_MONO            ," " stereo,mono "
group 0x004--0x007
 line.long 0 "PACP_GAIN_FCTR_L, Gain Factor Left Channel Register"
group 0x008--0x00B
 line.long 0 "PACP_GAIN_FCTR_R, Gain Factor Right Channel Register"
group 0x00C--0x00F
 line.long 0 "PACP_FIF_CFG, FIFO Configuration Register"
  textline ""
  bitfld.long 0  0.--6.  "    PACP_OUT_FIFO_WM      ," "    "
  textline ""
  bitfld.long 0  8.--14. "    PACP_IN_FIFO_WM       ," "    "
group 0x010--0x013
 line.long 0 "PACP_DIN_L, Data In Left Register"
group 0x014--0x017
 line.long 0 "PACP_DIN_R, Data In Right Register"
wgroup 0x018--0x01B
 hide.long 0 "PACP_FIFIN_L, FIFO In Left Register"
wgroup 0x01C--0x01F
 hide.long 0 "PACP_FIFIN_R, FIFO In Right Register"
group 0x020--0x023
 line.long 0 "PACP_INSTRUCT, Instruction Register"
group 0x024--0x027
 line.long 0 "PACP_COEFF, Coefficient Register"
group 0x028--0x02B
 line.long 0 "PACP_INDIR_COEFF, Indirect Coefficients Pointers Register"
  textline ""
  bitfld.long 0  0.--6.  "    COEF_PTR1             ," "    "
  textline ""
  bitfld.long 0  8.--14. "    COEF_PTR2             ," "    "
rgroup 0x02C--0x02F
 hide.long 0 "PACP_FIFOUT_L, FIFO Out Left Register"
  in
rgroup 0x030--0x033
 hide.long 0 "PACP_FIFOUT_R, FIFO Out Right Register"
  in
rgroup 0x034--0x037
 hide.long 0 "PACP_DO_L, Data Out Left Register"
  in
rgroup 0x038--0x03B
 hide.long 0 "PACP_DO_R, Data Out Right Register"
  in
rgroup 0x03C--0x03F
 line.long 0 "PACP_INT_DEBUG, InterruGpt Debug Register"
  textline ""
  bitfld.long 0  0. "    XMEM_CONT            ," " 0,1 "
  textline ""
  bitfld.long 0  1. "    XSTACK_ACC           ," " 0,1 "
  textline ""
  bitfld.long 0  2. "    XSTACK_OOR           ," " 0,1 "
  textline ""
  bitfld.long 0  3. "    XFIR_TOO_LNG         ," " 0,1 "
  textline ""
  bitfld.long 0  7. "    PACP_STRB_OUT        ," " 0,1 "
  textline ""
  bitfld.long 0  8. "    YMEM_CONT            ," " 0,1 "
  textline ""
  bitfld.long 0  9. "    YSTACK_ACC           ," " 0,1 "
  textline ""
  bitfld.long 0 10. "    YSTACK_OOR           ," " 0,1 "
  textline ""
  bitfld.long 0 11. "    YFIR_TOO_LNG         ," " 0,1 "
  textline ""
  bitfld.long 0 16. "    OUT_FIFO_R_WM        ," " 0,1 "
  textline ""
  bitfld.long 0 17. "    OUT_FIFO_L_WM        ," " 0,1 "
  textline ""
  bitfld.long 0 18. "    IN_FIFO_R_WM         ," " 0,1 "
  textline ""
  bitfld.long 0 19. "    IN_FIFO_L_WM         ," " 0,1 "
  textline ""
  bitfld.long 0 20. "    IN_FIFO_R_OVR        ," " 0,1 "
  textline ""
  bitfld.long 0 21. "    IN_FIFO_L_OVR        ," " 0,1 "
  textline ""
  bitfld.long 0 22. "    OUT_FIFO_R_UNR       ," " 0,1 "
  textline ""
  bitfld.long 0 23. "    OUT_FIFO_L_UNR       ," " 0,1 "
  textline ""
  bitfld.long 0 24. "    INPUT_STALL          ," " 0,1 "
  textline ""
  bitfld.long 0 25. "    OUTPUT_STAL          ," " 0,1 "
group 0x040--0x043
 line.long 0 "PACP_INT_MSK, Interrupt Mask Register"
rgroup 0x044--0x047
 line.long 0 "PACP_INT_CAUS, Interrupt Cause Register"
wgroup 0x048--0x04B
 hide.long 0 "PACP_INT_CLR, Interrupt Clear Register"
group 0x04C--0x04F
 line.long 0 "PACP_MEM_ACC_CTL, Memory Access Control Register"
  textline ""
  bitfld.long 0  0. "    AUTO_INC              ," "0,1"
  textline ""
  bitfld.long 0  1. "    PEND_WR_COEF          ," "0,1"
  textline ""
  bitfld.long 0  8.--15. "    DIRECT_ADD            ," "    "
group 0x050--0x053
 line.long 0 "PACP_MEM_LOW, Memory Low Register"
group 0x054--0x057
 line.long 0 "PACP_MEM_HIG, Memory High Register"
rgroup 0x058--0x05B
 line.long 0 "PACP_MEM_PTR, Memory Pointer Register"
  textline ""
  bitfld.long 0  0.--7.  "    MEM_RD_PTR            ," "    "
  textline ""
  bitfld.long 0  8.--15. "    MEM_WR_PTR            ," "    "
rgroup 0x05C--0x05F
 line.long 0 "PACP_PC_STAT, Program Counter Status Register"
rgroup 0x060--0x063
 line.long 0 "PACP_INST_STAT, Instruction Status Register"
  textline ""
  bitfld.long 0  0.--9.  "    OP_FETCH              ," "    "
  textline ""
  bitfld.long 0 10.--13. "    CMD_FETCH             ," "    "
  textline ""
  bitfld.long 0 15.      "    PACP_BUSY             ," "0,1"
rgroup 0x064--0x067
 line.long 0 "PACP_FIFO_STAT, FIFO Status Register"
  textline ""
  bitfld.long 0  0.--7.  "    PACP_OUT_FIFO_R_LVL   ," "    "
  textline ""
  bitfld.long 0  8.--15. "    PACP_OUT_FIFO_L_LVL   ," "    "
  textline ""
  bitfld.long 0 16.--23. "    PACP_IN_FIFO_R_LVL    ," "    "
  textline ""
  bitfld.long 0 24.--31. "    PACP_IN_FIFO_L_LVL    ," "    "
tree.end

;=====================================================
tree "PLICU    - Priority Level Interrupt Control Unit"
;=====================================================
base a:0x05100000
group 0x000--0x08F
  textline ""
  textline "  0: CORTEX              "
  setclrfld.long 0x34  0. 0x3C  0. 0x44  0. " " "disabled,enabled"
  bitfld.long 0x08  0. "   Type " "level,edge"
  bitfld.long 0x6C  0. " " "IRQ,FIQ"
  bitfld.long 0x4C  0.--3. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  0. "    Status " "--------,ASSERTED"
  textline "  1: DRAM BUS MONITOR    "
  setclrfld.long 0x34  1. 0x3C  1. 0x44  1. " " "disabled,enabled"
  bitfld.long 0x08  1. "   Type " "level,edge"
  bitfld.long 0x6C  1. " " "IRQ,FIQ"
  bitfld.long 0x4C  4.--7. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  1. "    Status " "--------,ASSERTED"
  textline "  2: USB1OTG_SOF_PULSE   "
  setclrfld.long 0x34  2. 0x3C  2. 0x44  2. " " "disabled,enabled"
  bitfld.long 0x08  2. "   Type " "level,edge"
  bitfld.long 0x6C  2. " " "IRQ,FIQ"
  bitfld.long 0x4C  8.--11. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  2. "    Status " "--------,ASSERTED"
  textline "  3: USB1OTG_MC_NINT     "
  setclrfld.long 0x34  3. 0x3C  3. 0x44  3. " " "disabled,enabled"
  bitfld.long 0x08  3. "   Type " "level,edge"
  bitfld.long 0x6C  3. " " "IRQ,FIQ"
  bitfld.long 0x4C 12.--15. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  3. "    Status " "--------,ASSERTED"
  textline "  4: KEYPAD              "
  setclrfld.long 0x34  4. 0x3C  4. 0x44  4. " " "disabled,enabled"
  bitfld.long 0x08  4. "   Type " "level,edge"
  bitfld.long 0x6C  4. " " "IRQ,FIQ"
  bitfld.long 0x4C 16.--19. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  4. "    Status " "--------,ASSERTED"
  textline "  5: CCU_ERROR           "
  setclrfld.long 0x34  5. 0x3C  5. 0x44  5. " " "disabled,enabled"
  bitfld.long 0x08  5. "   Type " "level,edge"
  bitfld.long 0x6C  5. " " "IRQ,FIQ"
  bitfld.long 0x4C 20.--23. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  5. "    Status " "--------,ASSERTED"
  textline "  6: CSS NORMAL          "
  setclrfld.long 0x34  6. 0x3C  6. 0x44  6. " " "disabled,enabled"
  bitfld.long 0x08  6. "   Type " "level,edge"
  bitfld.long 0x6C  6. " " "IRQ,FIQ"
  bitfld.long 0x4C 24.--27. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  6. "    Status " "--------,ASSERTED"
  textline "  7: SECURITY            "
  setclrfld.long 0x34  7. 0x3C  7. 0x44  7. " " "disabled,enabled"
  bitfld.long 0x08  7. "   Type " "level,edge"
  bitfld.long 0x6C  7. " " "IRQ,FIQ"
  bitfld.long 0x4C 28.--31. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  7. "    Status " "--------,ASSERTED"
  textline "  8: DRAM CONTROLLER     "
  setclrfld.long 0x34  8. 0x3C  8. 0x44  8. " " "disabled,enabled"
  bitfld.long 0x08  8. "   Type " "level,edge"
  bitfld.long 0x6C  8. " " "IRQ,FIQ"
  bitfld.long 0x50  0.--3. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  8. "    Status " "--------,ASSERTED"
  textline "  9: 3D GRAPHICS         "
  setclrfld.long 0x34  9. 0x3C  9. 0x44  9. " " "disabled,enabled"
  bitfld.long 0x08  9. "   Type " "level,edge"
  bitfld.long 0x6C  9. " " "IRQ,FIQ"
  bitfld.long 0x50  4.--7. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  9. "    Status " "--------,ASSERTED"
  textline " 10: VIDEO ENCODER       "
  setclrfld.long 0x34  10. 0x3C  10. 0x44  10. " " "disabled,enabled"
  bitfld.long 0x08  10. "   Type " "level,edge"
  bitfld.long 0x6C  10. " " "IRQ,FIQ"
  bitfld.long 0x50  8.--11. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  10. "    Status " "--------,ASSERTED"
  textline " 11: VIDEO DECODER       "
  setclrfld.long 0x34  11. 0x3C  11. 0x44  11. " " "disabled,enabled"
  bitfld.long 0x08  11. "   Type " "level,edge"
  bitfld.long 0x6C  11. " " "IRQ,FIQ"
  bitfld.long 0x50 12.--15. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  11. "    Status " "--------,ASSERTED"
  textline " 12: CIU                 "
  setclrfld.long 0x34  12. 0x3C  12. 0x44  12. " " "disabled,enabled"
  bitfld.long 0x08  12. "   Type " "level,edge"
  bitfld.long 0x6C  12. " " "IRQ,FIQ"
  bitfld.long 0x50 16.--19. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  12. "    Status " "--------,ASSERTED"
  textline " 13: SLAVE MII           "
  setclrfld.long 0x34  13. 0x3C  13. 0x44  13. " " "disabled,enabled"
  bitfld.long 0x08  13. "   Type " "level,edge"
  bitfld.long 0x6C  13. " " "IRQ,FIQ"
  bitfld.long 0x50 20.--23. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  13. "    Status " "--------,ASSERTED"
  textline " 14: LCD CONTROLLER      "
  setclrfld.long 0x34  14. 0x3C  14. 0x44  14. " " "disabled,enabled"
  bitfld.long 0x08  14. "   Type " "level,edge"
  bitfld.long 0x6C  14. " " "IRQ,FIQ"
  bitfld.long 0x50 24.--27. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  14. "    Status " "--------,ASSERTED"
  textline " 15: SW1                 "
  setclrfld.long 0x34  15. 0x3C  15. 0x44  15. " " "disabled,enabled"
  bitfld.long 0x08  15. "   Type " "level,edge"
  bitfld.long 0x6C  15. " " "IRQ,FIQ"
  bitfld.long 0x50 28.--31. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  15. "    Status " "--------,ASSERTED"
  textline " 16: MEMORY STICK        "
  setclrfld.long 0x34  16. 0x3C  16. 0x44  16. " " "disabled,enabled"
  bitfld.long 0x08  16. "   Type " "level,edge"
  bitfld.long 0x6C  16. " " "IRQ,FIQ"
  bitfld.long 0x54  0.--3. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  16. "    Status " "--------,ASSERTED"
  textline " 17: SDMMC HOST          "
  setclrfld.long 0x34  17. 0x3C  17. 0x44  17. " " "disabled,enabled"
  bitfld.long 0x08  17. "   Type " "level,edge"
  bitfld.long 0x6C  17. " " "IRQ,FIQ"
  bitfld.long 0x54  4.--7. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  17. "    Status " "--------,ASSERTED"
  textline " 18: OSDM                "
  setclrfld.long 0x34  18. 0x3C  18. 0x44  18. " " "disabled,enabled"
  bitfld.long 0x08  18. "   Type " "level,edge"
  bitfld.long 0x6C  18. " " "IRQ,FIQ"
  bitfld.long 0x54  8.--11. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  18. "    Status " "--------,ASSERTED"
  textline " 19: SEC                 "
  setclrfld.long 0x34  19. 0x3C  19. 0x44  19. " " "disabled,enabled"
  bitfld.long 0x08  19. "   Type " "level,edge"
  bitfld.long 0x6C  19. " " "IRQ,FIQ"
  bitfld.long 0x54 12.--15. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  19. "    Status " "--------,ASSERTED"
  textline " 20: GDMAC ERROR         "
  setclrfld.long 0x34  20. 0x3C  20. 0x44  20. " " "disabled,enabled"
  bitfld.long 0x08  20. "   Type " "level,edge"
  bitfld.long 0x6C  20. " " "IRQ,FIQ"
  bitfld.long 0x54 16.--19. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  20. "    Status " "--------,ASSERTED"
  textline " 21: GDMAC DMA DONE      "
  setclrfld.long 0x34  21. 0x3C  21. 0x44  21. " " "disabled,enabled"
  bitfld.long 0x08  21. "   Type " "level,edge"
  bitfld.long 0x6C  21. " " "IRQ,FIQ"
  bitfld.long 0x54 20.--23. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  21. "    Status " "--------,ASSERTED"
  textline " 22: FLASH CONTROLLER    "
  setclrfld.long 0x34  22. 0x3C  22. 0x44  22. " " "disabled,enabled"
  bitfld.long 0x08  22. "   Type " "level,edge"
  bitfld.long 0x6C  22. " " "IRQ,FIQ"
  bitfld.long 0x54 24.--27. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  22. "    Status " "--------,ASSERTED"
  textline " 23: 802.3 MAC           "
  setclrfld.long 0x34  23. 0x3C  23. 0x44  23. " " "disabled,enabled"
  bitfld.long 0x08  23. "   Type " "level,edge"
  bitfld.long 0x6C  23. " " "IRQ,FIQ"
  bitfld.long 0x54 28.--31. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  23. "    Status " "--------,ASSERTED"
  textline " 24: EXTERNAL REQUEST 0  "
  setclrfld.long 0x34  24. 0x3C  24. 0x44  24. " " "disabled,enabled"
  bitfld.long 0x08  24. "   Type " "level,edge"
  bitfld.long 0x6C  24. " " "IRQ,FIQ"
  bitfld.long 0x58  0.--3. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  24. "    Status " "--------,ASSERTED"
  textline " 25: EXTERNAL REQUEST 1  "
  setclrfld.long 0x34  25. 0x3C  25. 0x44  25. " " "disabled,enabled"
  bitfld.long 0x08  25. "   Type " "level,edge"
  bitfld.long 0x6C  25. " " "IRQ,FIQ"
  bitfld.long 0x58  4.--7. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  25. "    Status " "--------,ASSERTED"
  textline " 26: EXTERNAL REQUEST 2  "
  setclrfld.long 0x34  26. 0x3C  26. 0x44  26. " " "disabled,enabled"
  bitfld.long 0x08  26. "   Type " "level,edge"
  bitfld.long 0x6C  26. " " "IRQ,FIQ"
  bitfld.long 0x58  8.--11. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  26. "    Status " "--------,ASSERTED"
  textline " 27: EXTERNAL REQUEST 3  "
  setclrfld.long 0x34  27. 0x3C  27. 0x44  27. " " "disabled,enabled"
  bitfld.long 0x08  27. "   Type " "level,edge"
  bitfld.long 0x6C  27. " " "IRQ,FIQ"
  bitfld.long 0x58 12.--15. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  27. "    Status " "--------,ASSERTED"
  textline " 28: EXTERNAL REQUEST 4  "
  setclrfld.long 0x34  28. 0x3C  28. 0x44  28. " " "disabled,enabled"
  bitfld.long 0x08  28. "   Type " "level,edge"
  bitfld.long 0x6C  28. " " "IRQ,FIQ"
  bitfld.long 0x58 16.--19. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  28. "    Status " "--------,ASSERTED"
  textline " 29: EXTERNAL REQUEST 5  "
  setclrfld.long 0x34  29. 0x3C  29. 0x44  29. " " "disabled,enabled"
  bitfld.long 0x08  29. "   Type " "level,edge"
  bitfld.long 0x6C  29. " " "IRQ,FIQ"
  bitfld.long 0x58 20.--23. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  29. "    Status " "--------,ASSERTED"
  textline " 30: EXTERNAL REQUEST 6  "
  setclrfld.long 0x34  30. 0x3C  30. 0x44  30. " " "disabled,enabled"
  bitfld.long 0x08  30. "   Type " "level,edge"
  bitfld.long 0x6C  30. " " "IRQ,FIQ"
  bitfld.long 0x58 24.--27. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  30. "    Status " "--------,ASSERTED"
  textline " 31: SW2                 "
  setclrfld.long 0x34  31. 0x3C  31. 0x44  31. " " "disabled,enabled"
  bitfld.long 0x08  31. "   Type " "level,edge"
  bitfld.long 0x6C  31. " " "IRQ,FIQ"
  bitfld.long 0x58 28.--31. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x1C  31. "    Status " "--------,ASSERTED"
  textline " 32: EXTERNAL REQUEST 7  "
  setclrfld.long 0x38  0. 0x40  0. 0x48  0. " " "disabled,enabled"
  bitfld.long 0x0c  0. "   Type " "level,edge"
  bitfld.long 0x70  0. " " "IRQ,FIQ"
  bitfld.long 0x5C  0.--3. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  0. "    Status " "--------,ASSERTED"
  textline " 33: EXTERNAL REQUEST 8  "
  setclrfld.long 0x38  1. 0x40  1. 0x48  1. " " "disabled,enabled"
  bitfld.long 0x0c  1. "   Type " "level,edge"
  bitfld.long 0x70  1. " " "IRQ,FIQ"
  bitfld.long 0x5C  4.--7. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  1. "    Status " "--------,ASSERTED"
  textline " 34: EXTERNAL REQUEST 9  "
  setclrfld.long 0x38  2. 0x40  2. 0x48  2. " " "disabled,enabled"
  bitfld.long 0x0c  2. "   Type " "level,edge"
  bitfld.long 0x70  2. " " "IRQ,FIQ"
  bitfld.long 0x5C  8.--11. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  2. "    Status " "--------,ASSERTED"
  textline " 35: EXTERNAL REQUEST 10 "
  setclrfld.long 0x38  3. 0x40  3. 0x48  3. " " "disabled,enabled"
  bitfld.long 0x0c  3. "   Type " "level,edge"
  bitfld.long 0x70  3. " " "IRQ,FIQ"
  bitfld.long 0x5C 12.--15. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  3. "    Status " "--------,ASSERTED"
  textline " 36: EXTERNAL REQUEST 11 "
  setclrfld.long 0x38  4. 0x40  4. 0x48  4. " " "disabled,enabled"
  bitfld.long 0x0c  4. "   Type " "level,edge"
  bitfld.long 0x70  4. " " "IRQ,FIQ"
  bitfld.long 0x5C 16.--19. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  4. "    Status " "--------,ASSERTED"
  textline " 37: EXTERNAL REQUEST 12 "
  setclrfld.long 0x38  5. 0x40  5. 0x48  5. " " "disabled,enabled"
  bitfld.long 0x0c  5. "   Type " "level,edge"
  bitfld.long 0x70  5. " " "IRQ,FIQ"
  bitfld.long 0x5C 20.--23. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  5. "    Status " "--------,ASSERTED"
  textline " 38: EXTERNAL REQUEST 13 "
  setclrfld.long 0x38  6. 0x40  6. 0x48  6. " " "disabled,enabled"
  bitfld.long 0x0c  6. "   Type " "level,edge"
  bitfld.long 0x70  6. " " "IRQ,FIQ"
  bitfld.long 0x5C 24.--27. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  6. "    Status " "--------,ASSERTED"
  textline " 39: EXTERNAL REQUEST 14 "
  setclrfld.long 0x38  7. 0x40  7. 0x48  7. " " "disabled,enabled"
  bitfld.long 0x0c  7. "   Type " "level,edge"
  bitfld.long 0x70  7. " " "IRQ,FIQ"
  bitfld.long 0x5C 28.--31. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  7. "    Status " "--------,ASSERTED"
  textline " 40: EXTERNAL REQUEST 15 "
  setclrfld.long 0x38  8. 0x40  8. 0x48  8. " " "disabled,enabled"
  bitfld.long 0x0c  8. "   Type " "level,edge"
  bitfld.long 0x70  8. " " "IRQ,FIQ"
  bitfld.long 0x60  0.--3. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  8. "    Status " "--------,ASSERTED"
  textline " 41: RTC                 "
  setclrfld.long 0x38  9. 0x40  9. 0x48  9. " " "disabled,enabled"
  bitfld.long 0x0c  9. "   Type " "level,edge"
  bitfld.long 0x70  9. " " "IRQ,FIQ"
  bitfld.long 0x60  4.--7. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  9. "    Status " "--------,ASSERTED"
  textline " 42: SBUS2               "
  setclrfld.long 0x38  10. 0x40  10. 0x48  10. " " "disabled,enabled"
  bitfld.long 0x0c  10. "   Type " "level,edge"
  bitfld.long 0x70  10. " " "IRQ,FIQ"
  bitfld.long 0x60  8.--11. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  10. "    Status " "--------,ASSERTED"
  textline " 43: SBUS1               "
  setclrfld.long 0x38  11. 0x40  11. 0x48  11. " " "disabled,enabled"
  bitfld.long 0x0c  11. "   Type " "level,edge"
  bitfld.long 0x70  11. " " "IRQ,FIQ"
  bitfld.long 0x60 12.--15. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  11. "    Status " "--------,ASSERTED"
  textline " 44: SPI2                "
  setclrfld.long 0x38  12. 0x40  12. 0x48  12. " " "disabled,enabled"
  bitfld.long 0x0c  12. "   Type " "level,edge"
  bitfld.long 0x70  12. " " "IRQ,FIQ"
  bitfld.long 0x60 16.--19. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  12. "    Status " "--------,ASSERTED"
  textline " 45: SPI1                "
  setclrfld.long 0x38  13. 0x40  13. 0x48  13. " " "disabled,enabled"
  bitfld.long 0x0c  13. "   Type " "level,edge"
  bitfld.long 0x70  13. " " "IRQ,FIQ"
  bitfld.long 0x60 20.--23. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  13. "    Status " "--------,ASSERTED"
  textline " 46: TIMER 4             "
  setclrfld.long 0x38  14. 0x40  14. 0x48  14. " " "disabled,enabled"
  bitfld.long 0x0c  14. "   Type " "level,edge"
  bitfld.long 0x70  14. " " "IRQ,FIQ"
  bitfld.long 0x60 24.--27. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  14. "    Status " "--------,ASSERTED"
  textline " 47: SW3                 "
  setclrfld.long 0x38  15. 0x40  15. 0x48  15. " " "disabled,enabled"
  bitfld.long 0x0c  15. "   Type " "level,edge"
  bitfld.long 0x70  15. " " "IRQ,FIQ"
  bitfld.long 0x60 28.--31. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  15. "    Status " "--------,ASSERTED"
  textline " 48: TIMER 3             "
  setclrfld.long 0x38  16. 0x40  16. 0x48  16. " " "disabled,enabled"
  bitfld.long 0x0c  16. "   Type " "level,edge"
  bitfld.long 0x70  16. " " "IRQ,FIQ"
  bitfld.long 0x64  0.--3. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  16. "    Status " "--------,ASSERTED"
  textline " 49: TIMER 2             "
  setclrfld.long 0x38  17. 0x40  17. 0x48  17. " " "disabled,enabled"
  bitfld.long 0x0c  17. "   Type " "level,edge"
  bitfld.long 0x70  17. " " "IRQ,FIQ"
  bitfld.long 0x64  4.--7. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  17. "    Status " "--------,ASSERTED"
  textline " 50: TIMER 1             "
  setclrfld.long 0x38  18. 0x40  18. 0x48  18. " " "disabled,enabled"
  bitfld.long 0x0c  18. "   Type " "level,edge"
  bitfld.long 0x70  18. " " "IRQ,FIQ"
  bitfld.long 0x64  8.--11. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  18. "    Status " "--------,ASSERTED"
  textline " 51: WIFI MAC            "
  setclrfld.long 0x38  19. 0x40  19. 0x48  19. " " "disabled,enabled"
  bitfld.long 0x0c  19. "   Type " "level,edge"
  bitfld.long 0x70  19. " " "IRQ,FIQ"
  bitfld.long 0x64 12.--15. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  19. "    Status " "--------,ASSERTED"
  textline " 52: MAC                 "
  setclrfld.long 0x38  20. 0x40  20. 0x48  20. " " "disabled,enabled"
  bitfld.long 0x0c  20. "   Type " "level,edge"
  bitfld.long 0x70  20. " " "IRQ,FIQ"
  bitfld.long 0x64 16.--19. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  20. "    Status " "--------,ASSERTED"
  textline " 53: UART3               "
  setclrfld.long 0x38  21. 0x40  21. 0x48  21. " " "disabled,enabled"
  bitfld.long 0x0c  21. "   Type " "level,edge"
  bitfld.long 0x70  21. " " "IRQ,FIQ"
  bitfld.long 0x64 20.--23. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  21. "    Status " "--------,ASSERTED"
  textline " 54: UART2               "
  setclrfld.long 0x38  22. 0x40  22. 0x48  22. " " "disabled,enabled"
  bitfld.long 0x0c  22. "   Type " "level,edge"
  bitfld.long 0x70  22. " " "IRQ,FIQ"
  bitfld.long 0x64 24.--27. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  22. "    Status " "--------,ASSERTED"
  textline " 55: UART1               "
  setclrfld.long 0x38  23. 0x40  23. 0x48  23. " " "disabled,enabled"
  bitfld.long 0x0c  23. "   Type " "level,edge"
  bitfld.long 0x70  23. " " "IRQ,FIQ"
  bitfld.long 0x64 28.--31. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  23. "    Status " "--------,ASSERTED"
  textline " 56: USB2OTG_SOF_PULSE   "
  setclrfld.long 0x38  24. 0x40  24. 0x48  24. " " "disabled,enabled"
  bitfld.long 0x0c  24. "   Type " "level,edge"
  bitfld.long 0x70  24. " " "IRQ,FIQ"
  bitfld.long 0x68  0.--3. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  24. "    Status " "--------,ASSERTED"
  textline " 57: USB2OTG_MC_NINT     "
  setclrfld.long 0x38  25. 0x40  25. 0x48  25. " " "disabled,enabled"
  bitfld.long 0x0c  25. "   Type " "level,edge"
  bitfld.long 0x70  25. " " "IRQ,FIQ"
  bitfld.long 0x68  4.--7. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  25. "    Status " "--------,ASSERTED"
  textline " 58: TDM3                "
  setclrfld.long 0x38  26. 0x40  26. 0x48  26. " " "disabled,enabled"
  bitfld.long 0x0c  26. "   Type " "level,edge"
  bitfld.long 0x70  26. " " "IRQ,FIQ"
  bitfld.long 0x68  8.--11. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  26. "    Status " "--------,ASSERTED"
  textline " 59: TDM2                "
  setclrfld.long 0x38  27. 0x40  27. 0x48  27. " " "disabled,enabled"
  bitfld.long 0x0c  27. "   Type " "level,edge"
  bitfld.long 0x70  27. " " "IRQ,FIQ"
  bitfld.long 0x68 12.--15. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  27. "    Status " "--------,ASSERTED"
  textline " 60: TDM1                "
  setclrfld.long 0x38  28. 0x40  28. 0x48  28. " " "disabled,enabled"
  bitfld.long 0x0c  28. "   Type " "level,edge"
  bitfld.long 0x70  28. " " "IRQ,FIQ"
  bitfld.long 0x68 16.--19. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  28. "    Status " "--------,ASSERTED"
  textline " 61: PACP                "
  setclrfld.long 0x38  29. 0x40  29. 0x48  29. " " "disabled,enabled"
  bitfld.long 0x0c  29. "   Type " "level,edge"
  bitfld.long 0x70  29. " " "IRQ,FIQ"
  bitfld.long 0x68 20.--23. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  29. "    Status " "--------,ASSERTED"
  textline " 62: WD                  "
  setclrfld.long 0x38  30. 0x40  30. 0x48  30. " " "disabled,enabled"
  bitfld.long 0x0c  30. "   Type " "level,edge"
  bitfld.long 0x70  30. " " "IRQ,FIQ"
  bitfld.long 0x68 24.--27. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  30. "    Status " "--------,ASSERTED"
  textline " 63: SW4                 "
  setclrfld.long 0x38  31. 0x40  31. 0x48  31. " " "disabled,enabled"
  bitfld.long 0x0c  31. "   Type " "level,edge"
  bitfld.long 0x70  31. " " "IRQ,FIQ"
  bitfld.long 0x68 28.--31. "    Prio " " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long 0x20  31. "    Status " "--------,ASSERTED"
textline ""
tree.close "PENDING_REQ[12]"
rgroup 0x024--0x02B
  textline ""
  bitfld.long 0x00  0. "    ,CORTEX"              "-,CORTEX              "
  bitfld.long 0x00  1. "    ,DRAM BUS MONITOR"    "-,DRAM BUS MONITOR    "
  bitfld.long 0x00  2. "    ,USB1OTG_SOF_PULSE"   "-,USB1OTG_SOF_PULSE   "
  bitfld.long 0x00  3. "    ,USB1OTG_MC_NINT"     "-,USB1OTG_MC_NINT     "
  textline ""
  bitfld.long 0x00  4. "    ,KEYPAD"              "-,KEYPAD              "
  bitfld.long 0x00  5. "    ,CCU_ERROR"           "-,CCU_ERROR           "
  bitfld.long 0x00  6. "    ,CSS NORMAL"          "-,CSS NORMAL          "
  bitfld.long 0x00  7. "    ,SECURITY"            "-,SECURITY            "
  textline ""
  bitfld.long 0x00  8. "    ,DRAM CONTROLLER"     "-,DRAM CONTROLLER     "
  bitfld.long 0x00  9. "    ,3D GRAPHICS"         "-,3D GRAPHICS         "
  bitfld.long 0x00 10. "    ,VIDEO ENCODER"       "-,VIDEO ENCODER       "
  bitfld.long 0x00 11. "    ,VIDEO DECODER"       "-,VIDEO DECODER       "
  textline ""
  bitfld.long 0x00 12. "    ,CIU"                 "-,CIU                 "
  bitfld.long 0x00 13. "    ,SLAVE MII"           "-,SLAVE MII           "
  bitfld.long 0x00 14. "    ,LCD CONTROLLER"      "-,LCD CONTROLLER      "
  bitfld.long 0x00 15. "    ,SW1"                 "-,SW1                 "
  textline ""
  bitfld.long 0x00 16. "    ,MEMORY STICK"        "-,MEMORY STICK        "
  bitfld.long 0x00 17. "    ,SDMMC HOST"          "-,SDMMC HOST          "
  bitfld.long 0x00 18. "    ,OSDM"                "-,OSDM                "
  bitfld.long 0x00 19. "    ,SEC"                 "-,SEC                 "
  textline ""
  bitfld.long 0x00 20. "    ,GDMAC ERROR"         "-,GDMAC ERROR         "
  bitfld.long 0x00 21. "    ,GDMAC DMA DONE"      "-,GDMAC DMA DONE      "
  bitfld.long 0x00 22. "    ,FLASH CONTROLLER"    "-,FLASH CONTROLLER    "
  bitfld.long 0x00 23. "    ,802.3 MAC"           "-,802.3 MAC           "
  textline ""
  bitfld.long 0x00 24. "    ,EXTERNAL REQUEST 0"  "-,EXTERNAL REQUEST 0  "
  bitfld.long 0x00 25. "    ,EXTERNAL REQUEST 1"  "-,EXTERNAL REQUEST 1  "
  bitfld.long 0x00 26. "    ,EXTERNAL REQUEST 2"  "-,EXTERNAL REQUEST 2  "
  bitfld.long 0x00 27. "    ,EXTERNAL REQUEST 3"  "-,EXTERNAL REQUEST 3  "
  textline ""
  bitfld.long 0x00 28. "    ,EXTERNAL REQUEST 4"  "-,EXTERNAL REQUEST 4  "
  bitfld.long 0x00 29. "    ,EXTERNAL REQUEST 5"  "-,EXTERNAL REQUEST 5  "
  bitfld.long 0x00 30. "    ,EXTERNAL REQUEST 6"  "-,EXTERNAL REQUEST 6  "
  bitfld.long 0x00 31. "    ,SW2"                 "-,SW2                 "
  textline ""
  bitfld.long 0x04  0. "    ,EXTERNAL REQUEST 7"  "-,EXTERNAL REQUEST 7  "
  bitfld.long 0x04  1. "    ,EXTERNAL REQUEST 8"  "-,EXTERNAL REQUEST 8  "
  bitfld.long 0x04  2. "    ,EXTERNAL REQUEST 9"  "-,EXTERNAL REQUEST 9  "
  bitfld.long 0x04  3. "    ,EXTERNAL REQUEST 10" "-,EXTERNAL REQUEST 10 "
  textline ""
  bitfld.long 0x04  4. "    ,EXTERNAL REQUEST 11" "-,EXTERNAL REQUEST 11 "
  bitfld.long 0x04  5. "    ,EXTERNAL REQUEST 12" "-,EXTERNAL REQUEST 12 "
  bitfld.long 0x04  6. "    ,EXTERNAL REQUEST 13" "-,EXTERNAL REQUEST 13 "
  bitfld.long 0x04  7. "    ,EXTERNAL REQUEST 14" "-,EXTERNAL REQUEST 14 "
  textline ""
  bitfld.long 0x04  8. "    ,EXTERNAL REQUEST 15" "-,EXTERNAL REQUEST 15 "
  bitfld.long 0x04  9. "    ,RTC"                 "-,RTC                 "
  bitfld.long 0x04 10. "    ,SBUS2"               "-,SBUS2               "
  bitfld.long 0x04 11. "    ,SBUS1"               "-,SBUS1               "
  textline ""
  bitfld.long 0x04 12. "    ,SPI2"                "-,SPI2                "
  bitfld.long 0x04 13. "    ,SPI1"                "-,SPI1                "
  bitfld.long 0x04 14. "    ,TIMER 4"             "-,TIMER 4             "
  bitfld.long 0x04 15. "    ,SW3"                 "-,SW3                 "
  textline ""
  bitfld.long 0x04 16. "    ,TIMER 3"             "-,TIMER 3             "
  bitfld.long 0x04 17. "    ,TIMER 2"             "-,TIMER 2             "
  bitfld.long 0x04 18. "    ,TIMER 1"             "-,TIMER 1             "
  bitfld.long 0x04 19. "    ,WIFI MAC"            "-,WIFI MAC            "
  textline ""
  bitfld.long 0x04 20. "    ,MAC"                 "-,MAC                 "
  bitfld.long 0x04 21. "    ,UART3"               "-,UART3               "
  bitfld.long 0x04 22. "    ,UART2"               "-,UART2               "
  bitfld.long 0x04 23. "    ,UART1"               "-,UART1               "
  textline ""
  bitfld.long 0x04 24. "    ,USB2OTG_SOF_PULSE"   "-,USB2OTG_SOF_PULSE   "
  bitfld.long 0x04 25. "    ,USB2OTG_MC_NINT"     "-,USB2OTG_MC_NINT     "
  bitfld.long 0x04 26. "    ,TDM3"                "-,TDM3                "
  bitfld.long 0x04 27. "    ,TDM2"                "-,TDM2                "
  textline ""
  bitfld.long 0x04 28. "    ,TDM1"                "-,TDM1                "
  bitfld.long 0x04 29. "    ,PACP"                "-,PACP                "
  bitfld.long 0x04 30. "    ,WD"                  "-,WD                  "
  bitfld.long 0x04 31. "    ,SW4"                 "-,SW4                 "
tree.end
tree.close "FIQ_PENDING_REQ[12]"
rgroup 0x074--0x07B
  copy
tree.end
tree.close "CAUSE[12]"
rgroup 0x02C--0x033
  copy
tree.end
tree.close "FIQ_CAUSE[12]"
rgroup 0x07C--0x083
  copy
tree.end
textline ""
wgroup 0x000--0x003
 hide.long 0 "CH_CLR_INT1"
wgroup 0x004--0x007
 hide.long 0 "CH_CLR_INT2"
wgroup 0x010--0x013
 hide.long 0 "CH_SW_TRIG_SET1"
wgroup 0x014--0x017
 hide.long 0 "CH_SW_TRIG_SET2"
wgroup 0x018--0x01B
 hide.long 0 "SW_CH_REQ"
group 0x084--0x087
  line.long 0 "PRI_MASK"
group 0x088--0x08B
  line.long 0 "PRI_MASK_FIQ"
tree.end

;=====================================================
tree "RTC      - Real Time Clock"
;=====================================================
base a:0x05600000
group 0x000--0x003
 line.long 0 "RTCCFG"
  bitfld.long 0 1. ": RTCINTEN " " 0, 1"
  bitfld.long 0 0. " ALARMEN " " 0, 1"
group 0x004--0x007
 line.long 0 "RTCCTL"
  bitfld.long 0 0. ": SWRST " " 0, 1"
group 0x008--0x00B
 line.long 0 "RTCALARMVALUE"
rgroup 0x00C--0x00F
 line.long 0 "RTCSTATUS"
  bitfld.long 0 1. ": WRITEALARMVALEN " " 0, 1 "
  bitfld.long 0 0. " ALARM " " 0, 1 "
wgroup 0x010--0x013
 hide.long 0 "RTCINTCLR"
rgroup 0x014--0x017
 line.long 0 "RTCTIME"
tree.end

;=====================================================
tree "SEC      - Semaphores Exchange Center"
;=====================================================
base a:0x00a00000
rgroup 0x600--0x603
 line.long 0 "CPU2COM_STAT1"
rgroup 0x604--0x607
 line.long 0 "CPU2COM_STAT2"
rgroup 0x610--0x613
 line.long 0 "CPU2COM_OVR1"
rgroup 0x614--0x617
 line.long 0 "CPU2COM_OVR2"
group 0x640--0x643
 line.long 0 "COM2CPU_STAT1"
group 0x644--0x647
 line.long 0 "COM2CPU_STAT2"
group 0x648--0x64B
 line.long 0 "COM2CPU_MASK1"
group 0x64C--0x64F
 line.long 0 "COM2CPU_MASK2"
group 0x650--0x653
 line.long 0 "COM2CPU_OVR1"
group 0x654--0x657
 line.long 0 "COM2CPU_OVR2"
rgroup 0x658--0x65B
 line.long 0 "COM2CPU_CAUS1"
rgroup 0x65C--0x65F
 line.long 0 "COM2CPU_CAUS2"
rgroup 0x660--0x663
 line.long 0 "COM_CAUSE"
  textline ""
  bitfld.long 0 0. "    CPU1_REQ ," " 0, 1 "
  textline ""
  bitfld.long 0 1. "    CPU2_REQ ," " 0, 1 "
tree.end

;=====================================================
tree "SLVMII   - Slave MII/RMII"
;=====================================================
base a:0x06500000
group 0x000--0x003
 line.long 0 "SLVMII_CTRL, Control Register"
  textline ""
  bitfld.long 0  6. "    SPEED SELECTION      ," " 0,1 "
  textline ""
  bitfld.long 0  7. "    COLLISION TEST       ," " 0,1 "
  textline ""
  bitfld.long 0  8. "    DUPLEX MODE          ," " half,full "
  textline ""
  bitfld.long 0  9. "    RESTART AUTONEG      ," " 0,1 "
  textline ""
  bitfld.long 0 10. "    ISOLATE              ," " 0,1 "
  textline ""
  bitfld.long 0 11. "    POWER DOWN           ," " 0,1 "
  textline ""
  bitfld.long 0 12. "    AUTONEG ENABLE       ," " 0,1 "
  textline ""
  bitfld.long 0 13. "    SPEED SELECTION      ," " 10MB/s,100MB/s "
  textline ""
  bitfld.long 0 14. "    LOOPBACK             ," " 0,1 "
  textline ""
  bitfld.long 0 15. "    RESET                ," " 0,1 "
group 0x004--0x007
 line.long 0 "SLVMII_STAT, Status Register"
  textline ""
  bitfld.long 0  0. "    EXTENDED CAPABILITY  ," " 0,1 "
  textline ""
  bitfld.long 0  1. "    JABBER DETECT        ," " 0,1 "
  textline ""
  bitfld.long 0  2. "    LINK STATUS          ," " 0,1 "
  textline ""
  bitfld.long 0  3. "    AUTONEG ABILITY      ," " 0,1 "
  textline ""
  bitfld.long 0  4. "    REMOTE FAULT         ," " 0,1 "
  textline ""
  bitfld.long 0  5. "    AUTONEG COMPLETE     ," " 0,1 "
  textline ""
  bitfld.long 0  6. "    MF PREAMBLE SUPPR    ," " 0,1 "
  textline ""
  bitfld.long 0  8. "    EXTENDED STATUS      ," " 0,1 "
  textline ""
  bitfld.long 0  9. "    100BASE-T2 HALF DUP  ," " 0,1 "
  textline ""
  bitfld.long 0 10. "    100BASE-T2 FULL DUP  ," " 0,1 "
  textline ""
  bitfld.long 0 11. "    10 MB/S HALF DUP     ," " 0,1 "
  textline ""
  bitfld.long 0 12. "    10 MB/S FULL DUP     ," " 0,1 "
  textline ""
  bitfld.long 0 13. "    100BASE-X HALF DUP   ," " 0,1 "
  textline ""
  bitfld.long 0 14. "    100BASE-X FULL DUP   ," " 0,1 "
  textline ""
  bitfld.long 0 15. "    100BASE-T4           ," " 0,1 "
rgroup 0x008--0x00B
 line.long 0 "SLVMII_HWSTAT, Hardware Status"
  textline ""
  bitfld.long 0  0. "    BUSY_CTRL_WR         ," " 0,1 "
  textline ""
  bitfld.long 0  1. "    BUSY_STAT_RD         ," " 0,1 "
  textline ""
  bitfld.long 0  2. "    BUSY_CTRL_RD         ," " 0,1 "
group 0x00C--0x00F
 line.long 0 "SLVMII_CFG, Configuration Register"
  textline ""
  bitfld.long 0  0. "    PHY_EN               ," " 0,1 "
  textline ""
  bitfld.long 0  1. "    PHY_MODE             ," " 0,1 "
  textline ""
  bitfld.long 0  4.--8. "    PHY_ADDR              ," "    "
  textline ""
  bitfld.long 0  9. "    CRS_IN_FD            ," " 0,1 "
  textline ""
  bitfld.long 0 10. "    IE_ON_ISOLATE        ," " 0,1 "
  textline ""
  bitfld.long 0 11. "    CPU_CTRL_WR_EN       ," " 0,1 "
  textline ""
  bitfld.long 0 12. "    SW_RST               ," " 0,1 "
  textline ""
group 0x010--0x013
 line.long 0 "SLVMII_IE, Interrupt Enable Register"
  textline ""
  bitfld.long 0  0. "    SMI_CTL_RD_IE        ," " 0,1 "
  textline ""
  bitfld.long 0  1. "    SMI_STAT_RD_IE       ," " 0,1 "
  textline ""
  bitfld.long 0  2. "    SMI_CTL_WR_IE        ," " 0,1 "
rgroup 0x014--0x017
 line.long 0 "SLVMII_ISTAT, Interrupt Status Register"
  textline ""
  bitfld.long 0  0. "    SMI_CTL_RD           ," " 0,1 "
  textline ""
  bitfld.long 0  1. "    SMI_STAT_RD          ," " 0,1 "
  textline ""
  bitfld.long 0  2. "    SMI_CTL_WR           ," " 0,1 "
wgroup 0x018--0x01B
 hide.long 0 "SLVMII_ICLR, Interrupt Clear Register"
tree.end

;=====================================================
tree "SMC      - PL092 Static Memory Controller"
;=====================================================
base a:0x01000000
group 0x000--0xfff
 line.long 0x00 "SMBIDCYR0"
 line.long 0x04 "SMBWST1R0"
 line.long 0x08 "SMBWST2R0"
 line.long 0x0C "SMBWSTOENR0"
 line.long 0x10 "SMBWSTWENR0"
 line.long 0x14 "SMBCR0"
 line.long 0x18 "SMBSR0"
 line.long 0x1C "SMBIDCYR1"
 line.long 0x20 "SMBWST1R1"
 line.long 0x24 "SMBWST2R1"
 line.long 0x28 "SMBWSTOENR1"
 line.long 0x2C "SMBWSTWENR1"
 line.long 0x30 "SMBCR1"
 line.long 0x34 "SMBSR1"
 line.long 0x38 "SMBIDCYR2"
 line.long 0x3C "SMBWST1R2"
 line.long 0x40 "SMBWST2R2"
 line.long 0x44 "SMBWSTOENR2"
 line.long 0x48 "SMBWSTWENR2"
 line.long 0x4C "SMBCR2"
 line.long 0x50 "SMBSR2"
 line.long 0x54 "SMBIDCYR3"
 line.long 0x58 "SMBWST1R3"
 line.long 0x5C "SMBWST2R3"
 line.long 0x60 "SMBWSTOENR3"
 line.long 0x64 "SMBWSTWENR3"
 line.long 0x68 "SMBCR3"
 line.long 0x6C "SMBSR3"
 line.long 0x70 "SMBIDCYR4"
 line.long 0x74 "SMBWST1R4"
 line.long 0x78 "SMBWST2R4"
 line.long 0x7C "SMBWSTOENR4"
 line.long 0x80 "SMBWSTWENR4"
 line.long 0x84 "SMBCR4"
 line.long 0x88 "SMBSR4"
 line.long 0x8C "SMBIDCYR5"
 line.long 0x90 "SMBWST1R5"
 line.long 0x94 "SMBWST2R5"
 line.long 0x98 "SMBWSTOENR5"
 line.long 0x9C "SMBWSTWENR5"
 line.long 0xA0 "SMBCR5"
 line.long 0xA4 "SMBSR5"
 line.long 0xA8 "SMBIDCYR6"
 line.long 0xAC "SMBWST1R6"
 line.long 0xB0 "SMBWST2R6"
 line.long 0xB4 "SMBWSTOENR6"
 line.long 0xB8 "SMBWSTWENR6"
 line.long 0xBC "SMBCR6"
 line.long 0xC0 "SMBSR6"
 line.long 0xC4 "SMBIDCYR7"
 line.long 0xC8 "SMBWST1R7"
 line.long 0xCC "SMBWST2R7"
 line.long 0xD0 "SMBWSTOENR7"
 line.long 0xD4 "SMBWSTWENR7"
 line.long 0xD8 "SMBCR7"
 line.long 0xDC "SMBSR7"
 line.long 0xE0 "SMBEWS"
 line.long 0xFE0 "SMCPeriphID0"
 line.long 0xFE4 "SMCPeriphID1"
 line.long 0xFE8 "SMCPeriphID2"
 line.long 0xFEC "SMCPeriphID3"
 line.long 0xFF0 "SMCPCellID0"
 line.long 0xFF4 "SMCPCellID1"
 line.long 0xFF8 "SMCPCellID2"
 line.long 0xFFC "SMCPCellID3"
tree.end

;=====================================================
tree "SMS      - Memory Stick PRO-HG"
;=====================================================
base a:0x06800000
group 0x00--0x01
 line.word 0 "CONTROL"
group 0x02--0x03
 line.word 0 "PROGRAM_CNT"
group 0x004--0x007
 line.long 0 "SYSTEM"
group 0x008--0x00B
 line.long 0 "FLAG"
group 0x0c--0x0f
 line.long 0 "MEMORY_CTL"
group 0x010--0x011
 line.word 0 "GENERAL0"
group 0x012--0x013
 line.word 0 "GENERAL1"
group 0x014--0x015
 line.word 0 "GENERAL2"
group 0x016--0x017
 line.word 0 "GENERAL3"
group 0x018--0x019
 line.word 0 "GENERAL4"
group 0x01a--0x01b
 line.word 0 "GENERAL5"
group 0x01c--0x01f
 line.long 0 "TIMER"
group 0x020--0x023
 line.long 0 "INSTRUCT_QUEUE"
group 0x024--0x027
 line.long 0 "GENERAL_FIFO"
group 0x028--0x02B
 line.long 0 "PAGEBUFFER"
group 0x02c--0x02f
 line.long 0 "VERSION"
group 0x030--0x033
 line.long 0 "MSHC_CMD"
group 0x034--0x037
 line.long 0 "MSHC_DATA"
group 0x038--0x03B
 line.long 0 "MSHC_STATUS"
group 0x03c--0x03f
 line.long 0 "MSHC_SYS"
group 0x040--0x043
 line.long 0 "MSHC_USER"
group 0x044--0x047
 line.long 0 "MSHC_FIFO"
group 0x04C--0x04F
 line.long 0 "MSHC_DMA"
tree.end

;=====================================================
tree "SPI      - Serial Peripheral Interface"
;=====================================================
;-----------------------------------------------------
tree "SPI1"
;-----------------------------------------------------
base a:0x05d00000
group 0x000--0x003
 line.long 0 "CFG_REG, Configuration Register"
  textline ""
  bitfld.long 0 31. "    SPI_EN        ," " 0, 1 "
  bitfld.long 0 18. "TX_FIFO_FLUSH ," " 0, 1 "
  bitfld.long 0 17. "RX_FIFO_FLUSH ," " 0, 1 "
  bitfld.long 0 16. "TX_DMA_EN ," " 0, 1 "
  bitfld.long 0 15. "RX_DMA_EN  ," " 0, 1 "
  textline ""
  bitfld.long 0 13.--14. "    RX_TO_DURATION   ," "1024 PCLK cycles, 2048 PCLK cycles, 4096 PCLK cycles, 8192 PCLK cycles"
  hexmask.long.byte 0 9.--12. 0 "RX_IGNORE_N    ,"
  bitfld.long 0 8.  "           RX_IGNORE  ," " 0, 1 "
  textline ""
  bitfld.long 0 7.  "    DIRECT_CS     ," " 0, 1 "
  bitfld.long 0 6.  "SWCS          ," " 0, 1 "
  bitfld.long 0 5.  "DATA_ORD      ," " LSB first, MSB first "
  textline ""
  bitfld.long 0 4.  "    CS1_HOLD      ," " 0, 1 "
  bitfld.long 0 3.  "CS1_EN ," " enabled, disabled "
  bitfld.long 0 2.  "CS0_HOLD      ," " 0, 1 "
  bitfld.long 0 1.  "CS0_EN ," " enabled, disabled "
  textline ""
  bitfld.long 0 0.  "    CLKPOL        ," " active low, active high "
group 0x004--0x007
 line.long 0 "RATE_CNTL"
  textline ""
  bitfld.long 0 0.--3. "    BTRT_DIV   ," " divide by 2, divide by 4, divide by 8, divide by 16, divide by 32, divide by 64, divide by 128, divide by 256, divide by 512, divide by 1024, divide by 2048"
group 0x008--0x00B
 line.long 0 "INT_EN"
  textline ""
  hexmask.long.byte 0 12.--15. 1 "    TX_WM       ,"
  bitfld.long  0 9. " TX_FIFO_OV_INT_EN ," " 0, 1 "
  bitfld.long  0 8. "TX_FIFO_WM_INT_EN ," " 0, 1 "
  textline ""
  hexmask.long.byte 0   4.--7. 1 "    RX_WM       ,"
  bitfld.long  0 2. " RX_FIFO_UR        ," " 0, 1 "
  bitfld.long  0 1. "RX_TO_INT_EN      ," " 0, 1 "
  bitfld.long  0 0. "RX_FIFO_WM_EN     ," " 0, 1 "
rgroup 0x00C--0x00F
 line.long 0 "INT_STAT"
  textline ""
  bitfld.long  0 15. "    SPI_IDLE   ," " 0, 1 "
  bitfld.long  0 10. "SPI_BUSY   ," " 0, 1 "
  textline ""
  bitfld.long  0  9. "    TX_FIFO_OVR," " 0, 1 "
  bitfld.long  0  8. "TX_FIFO_WM ," " 0, 1 "
  textline ""
  bitfld.long  0 2. "    RX_FIFO_UR ," " 0, 1 "
  bitfld.long  0 1. "RX_TO      ," " 0, 1 "
  bitfld.long  0 0. "RX_FIFO_WM  ," " 0, 1 "
wgroup 0x010--0x013
 hide.long 0 "INT_CLR"
rgroup 0x014--0x017
 line.long 0 "INT_CAUSE"
  textline ""
  bitfld.long  0  9. "    TX_FIFO_OVR," " 0, 1 "
  bitfld.long  0  8. "TX_FIFO_WM ," " 0, 1 "
  textline ""
  bitfld.long  0 2. "    RX_FIFO_UR ," " 0, 1 "
  bitfld.long  0 1. "RX_TO      ," " 0, 1 "
  bitfld.long  0 0. "RX_FIFO_WM  ," " 0, 1 "
group 0x018--0x01B
 line.long 0 "TX_DAT"
rgroup 0x01C--0x01F
 hide.long 0 "RX_DAT"
   in
group 0x020--0x023
 line.long 0 "DEL_VAL"
rgroup 0x03C--0x03F
 hide.long 0 "RX_BUFF"
   in
rgroup 0x040--0x043
 line.long 0 "DBG"
tree.end

;-----------------------------------------------------
tree "SPI2"
;-----------------------------------------------------
base a:0x05e00000
group 0x000--0x003
 line.long 0 "CFG_REG, Configuration Register"
  textline ""
  bitfld.long 0 31. "    SPI_EN        ," " 0, 1 "
  bitfld.long 0 18. "TX_FIFO_FLUSH ," " 0, 1 "
  bitfld.long 0 17. "RX_FIFO_FLUSH ," " 0, 1 "
  bitfld.long 0 16. "TX_DMA_EN ," " 0, 1 "
  bitfld.long 0 15. "RX_DMA_EN  ," " 0, 1 "
  textline ""
  bitfld.long 0 13.--14. "    RX_TO_DURATION   ," "1024 PCLK cycles, 2048 PCLK cycles, 4096 PCLK cycles, 8192 PCLK cycles"
  hexmask.long.byte 0 9.--12. 0 "RX_IGNORE_N    ,"
  bitfld.long 0 8.  "           RX_IGNORE  ," " 0, 1 "
  textline ""
  bitfld.long 0 7.  "    DIRECT_CS     ," " 0, 1 "
  bitfld.long 0 6.  "SWCS          ," " 0, 1 "
  bitfld.long 0 5.  "DATA_ORD      ," " LSB first, MSB first "
  textline ""
  bitfld.long 0 4.  "    CS1_HOLD      ," " 0, 1 "
  bitfld.long 0 3.  "CS1_EN ," " enabled, disabled "
  bitfld.long 0 2.  "CS0_HOLD      ," " 0, 1 "
  bitfld.long 0 1.  "CS0_EN ," " enabled, disabled "
  textline ""
  bitfld.long 0 0.  "    CLKPOL        ," " active low, active high "
group 0x004--0x007
 line.long 0 "RATE_CNTL"
  textline ""
  bitfld.long 0 0.--3. "    BTRT_DIV   ," " divide by 2, divide by 4, divide by 8, divide by 16, divide by 32, divide by 64, divide by 128, divide by 256, divide by 512, divide by 1024, divide by 2048"
group 0x008--0x00B
 line.long 0 "INT_EN"
  textline ""
  hexmask.long.byte 0 12.--15. 1 "    TX_WM       ,"
  bitfld.long  0 9. " TX_FIFO_OV_INT_EN ," " 0, 1 "
  bitfld.long  0 8. "TX_FIFO_WM_INT_EN ," " 0, 1 "
  textline ""
  hexmask.long.byte 0   4.--7. 1 "    RX_WM       ,"
  bitfld.long  0 2. " RX_FIFO_UR        ," " 0, 1 "
  bitfld.long  0 1. "RX_TO_INT_EN      ," " 0, 1 "
  bitfld.long  0 0. "RX_FIFO_WM_EN     ," " 0, 1 "
rgroup 0x00C--0x00F
 line.long 0 "INT_STAT"
  textline ""
  bitfld.long  0 15. "    SPI_IDLE   ," " 0, 1 "
  bitfld.long  0 10. "SPI_BUSY   ," " 0, 1 "
  textline ""
  bitfld.long  0  9. "    TX_FIFO_OVR," " 0, 1 "
  bitfld.long  0  8. "TX_FIFO_WM ," " 0, 1 "
  textline ""
  bitfld.long  0 2. "    RX_FIFO_UR ," " 0, 1 "
  bitfld.long  0 1. "RX_TO      ," " 0, 1 "
  bitfld.long  0 0. "RX_FIFO_WM  ," " 0, 1 "
wgroup 0x010--0x013
 hide.long 0 "INT_CLR"
rgroup 0x014--0x017
 line.long 0 "INT_CAUSE"
  textline ""
  bitfld.long  0  9. "    TX_FIFO_OVR," " 0, 1 "
  bitfld.long  0  8. "TX_FIFO_WM ," " 0, 1 "
  textline ""
  bitfld.long  0 2. "    RX_FIFO_UR ," " 0, 1 "
  bitfld.long  0 1. "RX_TO      ," " 0, 1 "
  bitfld.long  0 0. "RX_FIFO_WM  ," " 0, 1 "
group 0x018--0x01B
 line.long 0 "TX_DAT"
rgroup 0x01C--0x01F
 hide.long 0 "RX_DAT"
   in
group 0x020--0x023
 line.long 0 "DEL_VAL"
rgroup 0x03C--0x03F
 hide.long 0 "RX_BUFF"
   in
rgroup 0x040--0x043
 line.long 0 "DBG"
tree.end
tree.end

;=====================================================
tree "SYSCFG   - System Configuration"
;=====================================================
base a:0x05200000
rgroup 0x000--0x003
 line.long 0 "GCR0, General Control Register 0"
group 0x004--0x007
 line.long 0 "GCR1, General Control Register 1"
  textline ""
  bitfld.long 0  0. "    ROMWS                ," " no wait states, 1 wait states "
  textline ""
  bitfld.long 0  2. "    CSS_INIT_RAM         ," " AHB RAM, ITCM "
  textline ""
  bitfld.long 0  5. "    ETHERNET_PHY_SEL     ," " MII, RMII "
  textline ""
  bitfld.long 0  7. "    32K_OSC_DRV          ," " normal, low-power "
  textline ""
  bitfld.long 0  8. "    CIU_MIPI_MODE        ," " CCIR, MIPI "
  textline ""
  bitfld.long 0 11. "    DBGNOCLOCKSTOP       ," " stopped, active "
  textline ""
  bitfld.long 0 12. "    CDBGRSTACK           ," " reset on-going, reset complete "
rgroup 0x008--0x00B
 line.long 0 "GCR2, General Control Register 2"
group 0x00C--0x00F
 line.long 0 "CORTEX_IR, Cortex Interrupts Register"
  textline ""
  bitfld.long 0 0. "    DMASIRQ              ," " 0, 1 "
  textline ""
  bitfld.long 0 1. "    DMAIRQ               ," " 0, 1 "
  textline ""
  bitfld.long 0 2. "    DMAEXTERRIRQ         ," " 0, 1 "
  textline ""
  bitfld.long 0 3. "    PMUIRQ               ," " 0, 1 "
  textline ""
  bitfld.long 0 4. "    CORTEX_CTIIRQ        ," " 0, 1 "
  textline ""
  bitfld.long 0 5. "    DBG_RST_REQ_NEG      ," " 0, 1 "
  textline ""
  bitfld.long 0 6. "    DBG_RST_REQ_POS      ," " 0, 1 "
  textline ""
  bitfld.long 0 7. "    DBG_RST_REQ          ," " 0, 1 "
  textline ""
  bitfld.long 0 8. "    DBG_RST_REQN         ," " 0, 1 "
rgroup 0x014--0x017
 line.long 0 "SYSOPT_CFG, System Configuration Options Register"
  textline ""
  bitfld.long 0  0. "    DIS_CSS_CPU          ," " enabled, disabled "
  textline ""
  bitfld.long 0  1. "    DIS_VIDEO_DECODER    ," " enabled, disabled "
  textline ""
  bitfld.long 0  2. "    DIS_VIDEO_ENCODER    ," " enabled, disabled "
  textline ""
  bitfld.long 0  3. "    DIS_3D_GRAPHICS      ," " enabled, disabled "
  textline ""
  bitfld.long 0  4. "    DIS_SONY_MS          ," " enabled, disabled "
  textline ""
  bitfld.long 0  5. "    EN_SECURE_BOOT       ," " disabled, enabled "
  textline ""
  bitfld.long 0  6. "    DIS_DBG_EN_OVR       ," " enabled, disabled "
  textline ""
  bitfld.long 0  7. "    DIS_REFERENCE_BUFFER ," " enabled, disabled "
  textline ""
  bitfld.long 0 12. "    DIS_CIF              ," " enabled, disabled "
  textline ""
  bitfld.long 0 13. "    DIS_D1               ," " enabled, disabled "
  textline ""
  bitfld.long 0 14. "    DIS_720P             ," " enabled, disabled "
  textline ""
  bitfld.long 0 15. "    DIS_1080P            ," " enabled, disabled "
  textline ""
  bitfld.long 0 19. "    DIS_AVS              ," " enabled, disabled "
  textline ""
  bitfld.long 0 20. "    DIS_VP8              ," " enabled, disabled "
  textline ""
  bitfld.long 0 21. "    DIS_VP7              ," " enabled, disabled "
  textline ""
  bitfld.long 0 22. "    DIS_RV               ," " enabled, disabled "
  textline ""
  bitfld.long 0 23. "    DIS_DIVX             ," " enabled, disabled "
  textline ""
  bitfld.long 0 25. "    DIS_VC1              ," " enabled, disabled "
  textline ""
  bitfld.long 0 26. "    DIS_VP6              ," " enabled, disabled "
  textline ""
  bitfld.long 0 27. "    DIS_JPEG             ," " enabled, disabled "
  textline ""
  bitfld.long 0 28. "    DIS_SORENSON_SPARK   ," " enabled, disabled "
  textline ""
  bitfld.long 0 29. "    DIS_MPEG2_MPEG1      ," " enabled, disabled "
  textline ""
  bitfld.long 0 30. "    DIS_MPEG4_H.263      ," " enabled, disabled "
  textline ""
  bitfld.long 0 31. "    DIS_H264_DECODE      ," " enabled, disabled "
group 0x018--0x01B
 line.long 0 "VIDEO_DEC_PP, Video Decoder Post Processor Register"
  textline ""
  bitfld.long 0 12. "    VIDEO_DEC_CIF        ," " disabled, enabled "
  textline ""
  bitfld.long 0 13. "    VIDEO_DEC_D1         ," " disabled, enabled "
  textline ""
  bitfld.long 0 14. "    VIDEO_DEC_720P       ," " disabled, enabled "
  textline ""
  bitfld.long 0 15. "    VIDEO_DEC_1080P      ," " disabled, enabled "
  textline ""
  bitfld.long 0 29. "    VIDEO_DEC_ALPHA      ," " disabled, enabled "
  textline ""
  bitfld.long 0 30. "    VIDEO_DEC_DEINTERLACE," " disabled, enabled "
  textline ""
  bitfld.long 0 31. "    VIDEO_DEC_PP         ," " disabled, enabled "
rgroup 0x01C--0x01F
 line.long 0 "CHIP_ID, HW Identification Register"
rgroup 0x020--0x023
 line.long 0 "CHIP_REV, HW Revision Register"
group 0x024--0x027
 line.long 0 "BMP_CTL, BMP Control Register"
  textline ""
  hexmask.long.byte 0 0.--2. 1 "    XTALDACFRAC           ,"
  textline ""
  hexmask.long.byte 0 3.--8. 1 "    XTALDAC               ,"
  textline ""
  bitfld.long 0 10.       "    BCLK_EN              ," " enabled, disabled "
group 0x02C--0x02F
 line.long 0 "ISO_CTL, Isolation Control Register"
  textline ""
  bitfld.long 0  0. "    CORTEX_NEON_ISO      ," " isolated, connected "
  textline ""
  bitfld.long 0  1. "    CORTEX_ETM_ISO       ," " isolated, connected "
  textline ""
  bitfld.long 0  2. "    VIDEO_ENC_DEC_ISO    ," " isolated, connected "
  textline ""
  bitfld.long 0  3. "    GPU_ISO              ," " isolated, connected "
  textline ""
  bitfld.long 0  4. "    CSS_ISO              ," " isolated, connected "
group 0x030--0x033
 line.long 0 "POWER_EN, Power Enable Register"
  textline ""
  bitfld.long 0  0. "    CORTEX_NEON_EN       ," " off, on "
  textline ""
  bitfld.long 0  1. "    CORTEX_ETM_EN        ," " off, on "
  textline ""
  bitfld.long 0  2. "    VIDEO_ENC_DEC_EN     ," " off, on "
  textline ""
  bitfld.long 0  3. "    GPU_EN               ," " off, on "
  textline ""
  bitfld.long 0  4. "    CSS_EN               ," " off, on "
  textline ""
  bitfld.long 0  5. "    AUTO_PWR_HILO        ," " software, hardware "
  textline ""
  bitfld.long 0  6. "    SW_PWR_HILO0         ," " 0, 1 "
  textline ""
  bitfld.long 0  7. "    SW_PWR_HILO1         ," " 0, 1 "
  textline ""
  hexmask.long.byte 0  8.--12. 1 "    AFE_LDO_LVL           ,"
  textline ""
  hexmask.long.byte 0 13.--15. 1 "    AFE_BG_TRIM           ,"
  textline ""
  bitfld.long 0 16. "    TRACE_BUF_ON_OVR     ," " 0, 1 "
  textline ""
  bitfld.long 0 17. "    DBG_CLK_ON_OVR       ," " 0, 1 "
  textline ""
  bitfld.long 0 18. "    DBG_RST              ," " 0, 1 "
  textline ""
  bitfld.long 0 19. "    SYS_PWR_ON           ," " 0, 1 "
  textline ""
  bitfld.long 0 20. "    DBG_PWR_ON           ," " 0, 1 "
  textline ""
  bitfld.long 0 21. "    WIFI_LDO_MODE        ," " 0, 1 "
  textline ""
  bitfld.long 0 22. "    WIFI_LDO_ECO         ," " normal, low-power "
  textline ""
  bitfld.long 0 23. "    WIFI_LDO_SW_EN       ," " off, on "
wgroup 0x040--0x043
 hide.long 0 "TEST_CTRL_EN, Test Control Enable Register"
group 0x044--0x047
 line.long 0 "TEST_CTRL1, Test Control Register"
  textline ""
  bitfld.long 0  2. "    WD_TEST              ," " normal, test mode "
  textline ""
  bitfld.long 0  3. "    ICU_TEST             ," " normal, test mode "
  textline ""
  bitfld.long 0  4. "    RAM_TEST             ," " normal, test mode "
  textline ""
  bitfld.long 0  6. "    TIMER_DBG_EN         ," " not affected, stopped "
  textline ""
  bitfld.long 0  7. "    RTC_DBG_EN           ," " not affected, stopped "
  textline ""
  bitfld.long 0  8. "    DBM_TEST_MODE        ," " normal, test mode "
  textline ""
  bitfld.long 0 11. "    PHY_MODE             ," " not used, active "
  textline ""
  bitfld.long 0 12. "    IO_IE_LOOPBCK_EN     ," " off, on "
  textline ""
  bitfld.long 0 14. "    WIFI_MAC_TEST_BUS    ," " 0, 1 "
  textline ""
  bitfld.long 0 15. "    WIFI_PHY_TEST_BUS    ," " 0, 1 "
  textline ""
  bitfld.long 0 17. "    BMP_DEBUG_ON         ," " disabled, enabled "
  textline ""
  bitfld.long 0 18. "    AFETOP_SPIEN         ," " 0, 1 "
  textline ""
  bitfld.long 0 19. "    AFETOP_SPIDO         ," " 0, 1 "
  textline ""
  bitfld.long 0 20. "    AFETOP_SPICLK        ," " 0, 1 "
  textline ""
  bitfld.long 0 21. "    AFETOP_SPIDI         ," " 0, 1 "
  textline ""
  bitfld.long 0 22. "    ADC1_SPIEN           ," " 0, 1 "
  textline ""
  bitfld.long 0 23. "    ADC1_SPIDO           ," " 0, 1 "
  textline ""
  bitfld.long 0 24. "    ADC1_SPICLK          ," " 0, 1 "
  textline ""
  bitfld.long 0 25. "    ADC1_SPIDI           ," " 0, 1 "
  textline ""
  bitfld.long 0 26. "    ADC0_SPIEN           ," " 0, 1 "
  textline ""
  bitfld.long 0 27. "    ADC0_SPIDO           ," " 0, 1 "
  textline ""
  bitfld.long 0 28. "    ADC0_SPICLK          ," " 0, 1 "
  textline ""
  bitfld.long 0 29. "    ADC0_SPIDI           ," " 0, 1 "
  textline ""
  bitfld.long 0 30. "    AFE_SPI_TEST_MODE    ," " 0, 1 "
group 0x048--0x04B
 line.long 0 "TEST_CTRL2, Test Control Register 2"
  textline ""
  bitfld.long 0  0. "    CC_SEQ_TM            ," " 2 clock cycles, 60 clock cycles "
  textline ""
  bitfld.long 0  4.--6. "    MIPI_TEST_CONTROL     ," " "
group 0x054--0x057
 line.long 0 "SPCR1, System Pins Control Register 1"
  textline ""
  hexmask.long.word 0  0.--8. 1 "    LCDGP_PAD_EN          ,"
  textline ""
  bitfld.long 0  10. "    LCDC_PAD_EN          ," " disabled, enabled "
  textline ""
  bitfld.long 0  11. "    SLVMII_PAD_EN        ," " disabled, enabled "
  textline ""
  bitfld.long 0  12. "    EMMC_PAD_EN          ," " disabled, enabled "
  textline ""
  bitfld.long 0  13. "    MS_PAD_EN            ," " disabled, enabled "
  textline ""
  bitfld.long 0  14. "    EMACA_PAD_EN         ," " disabled, enabled "
  textline ""
  bitfld.long 0  15. "    SD_PAD_EN            ," " disabled, enabled "
  textline ""
  bitfld.long 0  16. "    I2C_2_PAD_EN         ," " disabled, enabled "
  textline ""
  bitfld.long 0  17. "    I2C_1_PAD_EN         ," " disabled, enabled "
  textline ""
  bitfld.long 0  18. "    SLVRMII_PAD_EN       ," " disabled, enabled "
  textline ""
  bitfld.long 0  19. "    SPI2_PAD_EN          ," " disabled, enabled "
  textline ""
  bitfld.long 0  20. "    SPI1_PAD_EN          ," " disabled, enabled "
  textline ""
  bitfld.long 0  21. "    TDM3_PAD_EN          ," " disabled, enabled "
  textline ""
  bitfld.long 0  22. "    TDM2_PAD_EN          ," " disabled, enabled "
  textline ""
  bitfld.long 0  23. "    TDM1_PAD_EN          ," " disabled, enabled "
  textline ""
  bitfld.long 0  24. "    UART3_PAD_EN         ," " disabled, enabled "
  textline ""
  bitfld.long 0  25. "    UART2_PAD_EN         ," " disabled, enabled "
  textline ""
  bitfld.long 0  26. "    UART1_PAD_EN         ," " disabled, enabled "
  textline ""
  bitfld.long 0  27. "    FC_PAD_EN            ," " disabled, enabled "
  textline ""
  bitfld.long 0  28. "    IR_REMCTL_PAD_EN     ," " disabled, enabled "
  textline ""
  bitfld.long 0  29. "    BB_PAD_EN            ," " disabled, enabled "
  textline ""
  bitfld.long 0  30. "    MEMBOOT_PAD_EN       ," " disabled, enabled "
  textline ""
  bitfld.long 0  31. "    BTIF_PAD_EN          ," " disabled, enabled "
group 0x058--0x05B
 line.long 0 "SPCR2, System Pins Control Register 2"
  textline ""
  bitfld.long 0   0. "    SIM_PAD_EN           ," " disabled, enabled "
  textline ""
  bitfld.long 0   1. "    DP_CLK_PAD_EN        ," " disabled, enabled "
  textline ""
  bitfld.long 0   2. "    DECT_IF_PAD_EN       ," " disabled, enabled "
  textline ""
  bitfld.long 0   3. "    CIU_PAD_EN           ," " disabled, enabled "
  textline ""
  bitfld.long 0   4. "    CLK_OUT_PAD_EN       ," " disabled, enabled "
  textline ""
  bitfld.long 0   6. "    BMP_PAD_EN           ," " disabled, enabled "
  textline ""
  bitfld.long 0  16. "    WIFI_SER_KEEP_EN     ," " disabled, enabled "
group 0x05C--0x05F
 line.long 0 "USBOTG1_GCR1, USBOTG1 - PHY General Control Register 1"
  textline ""
  bitfld.long 0  0. "    USB1_TmaXBITS_STFFEN   ," " disabled, enabled "
  textline ""
  bitfld.long 0  1. "    USB1_TXBITS_STFFENH  ," " disabled, enabled "
  textline ""
  bitfld.long 0  2. "    USB1_OTG_DIS         ," " powered up, powered down "
  textline ""
  bitfld.long 0  3. "    USB1_BIST_EN         ," " normal mode, BIST mode "
  textline ""
  bitfld.long 0  4. "    USB1_HS_BIST         ," " normal mode, high-speed BIST "
  textline ""
  bitfld.long 0  5. "    USB1_FS_BIST         ," " normal mode, full-speed BIST "
  textline ""
  bitfld.long 0  6. "    USB1_LS_BIST         ," " normal mode, low-speed BIST "
  textline ""
  bitfld.long 0  7. "    USB1_SLEEPM          ," " sleep mode, normal mode "
  textline ""
  bitfld.long 0  8. "    USB1_VATESTENB       ," " disabled, enabled "
  textline ""
  bitfld.long 0  9. "    USB1_LOOPBACKEN      ," " disabled, active "
  textline ""
  bitfld.long 0 10. "    USB1_COMMON          ," " active, disabled "
  textline ""
  bitfld.long 0 11.--13. "    USB1_OTGTUNE          ," " "
  textline ""
  bitfld.long 0 14.--16. "    USB1_COMPDISTUNE      ," " "
  textline ""
  bitfld.long 0 17.--19. "    USB1_SQRXTUNE         ," " "
  textline ""
  bitfld.long 0 20.--21. "    USB1_TXHSXVTUNE       ," " "
  textline ""
  bitfld.long 0 22.--25. "    USB1_TXFSLSTUNE       ," " "
  textline ""
  bitfld.long 0 26.--29. "    USB1_TXVREFTUNE       ," " "
  textline ""
  bitfld.long 0 30. "    USB1_TXRISETUNE      ," " default, -8% "
  textline ""
  bitfld.long 0 31. "    USB1_TXPEEMPHTUNE    ," " disabled, enabled "
group 0x060--0x063
 line.long 0 "USBOTG1_GCR2, USBOTG1 - PHY General Control Register 2"
  textline ""
  bitfld.long 0  0.--1. "    USB1_SCLDWNMODE       ," " "
  textline ""
  bitfld.long 0  2. "    USB1_PHY_TM          ," " 0, 1 "
  textline ""
  bitfld.long 0  3. "    USB1_PHY_SIDDQ       ," " 0, 1 "
  textline ""
  bitfld.long 0  4. "    USB1_TESTBUS_EN      ," " 0, 1 "
  textline ""
  bitfld.long 0  2. "    USB1_BISTERROR       ," " no error, BIST error "
  textline ""
  bitfld.long 0  2. "    USB1_BISTDONE        ," " ongoing, completed "
group 0x064--0x067
 line.long 0 "USBOTG2_GCR1, USBOTG2 - PHY General Control Register 1"
  textline ""
  bitfld.long 0  0. "    USB2_TXBITS_STFFEN   ," " disabled, enabled "
  textline ""
  bitfld.long 0  1. "    USB2_TXBITS_STFFENH  ," " disabled, enabled "
  textline ""
  bitfld.long 0  2. "    USB2_OTG_DIS         ," " powered up, powered down "
  textline ""
  bitfld.long 0  3. "    USB2_BIST_EN         ," " normal mode, BIST mode "
  textline ""
  bitfld.long 0  4. "    USB2_HS_BIST         ," " normal mode, high-speed BIST "
  textline ""
  bitfld.long 0  5. "    USB2_FS_BIST         ," " normal mode, full-speed BIST "
  textline ""
  bitfld.long 0  6. "    USB2_LS_BIST         ," " normal mode, low-speed BIST "
  textline ""
  bitfld.long 0  7. "    USB2_SLEEPM          ," " sleep mode, normal mode "
  textline ""
  bitfld.long 0  8. "    USB2_VATESTENB       ," " disabled, enabled "
  textline ""
  bitfld.long 0  9. "    USB2_LOOPBACKEN      ," " disabled, active "
  textline ""
  bitfld.long 0 10. "    USB2_COMMON          ," " active, disabled "
  textline ""
  bitfld.long 0 11.--13. "    USB2_OTGTUNE          ," " "
  textline ""
  bitfld.long 0 14.--16. "    USB2_COMPDISTUNE      ," " "
  textline ""
  bitfld.long 0 17.--19. "    USB2_SQRXTUNE         ," " "
  textline ""
  bitfld.long 0 20.--21. "    USB2_TXHSXVTUNE       ," " "
  textline ""
  bitfld.long 0 22.--25. "    USB2_TXFSLSTUNE       ," " "
  textline ""
  bitfld.long 0 26.--29. "    USB2_TXVREFTUNE       ," " "
  textline ""
  bitfld.long 0 30. "    USB2_TXRISETUNE      ," " default, -8% "
  textline ""
  bitfld.long 0 31. "    USB2_TXPEEMPHTUNE    ," " disabled, enabled "
group 0x068--0x06B
 line.long 0 "USBOTG2_GCR2, USBOTG2 - PHY General Control Register 2"
  textline ""
  bitfld.long 0  0.--1. "    USB2_SCLDWNMODE       ," " "
  textline ""
  bitfld.long 0  2. "    USB2_PHY_TM          ," " 0, 1 "
  textline ""
  bitfld.long 0  3. "    USB2_PHY_SIDDQ       ," " 0, 1 "
  textline ""
  bitfld.long 0  4. "    USB2_TESTBUS_EN      ," " 0, 1 "
  textline ""
  bitfld.long 0  2. "    USB2_BISTERROR       ," " no error, BIST error "
  textline ""
  bitfld.long 0  2. "    USB2_BISTDONE        ," " ongoing, completed "
group 0x06C--0x06F
 line.long 0 "DRAMCTL_GCR1, DRAMCTL General Control Register 1"
  textline ""
  bitfld.long 0  0. "    SREFRESH_ENTER       ," " 0, 1 "
  textline ""
  bitfld.long 0  1. "    AXI0_COHR_CTL        ," " 0, 1 "
  textline ""
  bitfld.long 0  2. "    AXI1_COHR_CTL        ," " 0, 1 "
  textline ""
  bitfld.long 0  3. "    AXI2_COHR_CTL        ," " 0, 1 "
  textline ""
  bitfld.long 0  4. "    AXI3_COHR_CTL        ," " 0, 1 "
  textline ""
  bitfld.long 0 20.--27. "    DRAM_PORT_BUSY       ," " 0, 1 "
  textline ""
  bitfld.long 0 28. "    DRAM_Q_ALMOST_FULL   ," " 0, 1 "
  textline ""
  bitfld.long 0 29. "    DRAM_CTL_BUSY        ," " 0, 1 "
  textline ""
  bitfld.long 0 30. "    SREFRESH_ACK         ," " 0, 1 "
  textline ""
  bitfld.long 0 31. "    DRAM_REFRESH_ON      ," " 0, 1 "
group 0x070--0x073
 line.long 0 "DRAMCTL_GCR2, Spare for DRAMCTL"
group 0x074--0x077
 line.long 0 "MEM_CFG, Memory Configuration Register"
  textline ""
  bitfld.long 0 0.--2.   "    T_RWM_CORTEX          ," " "
  textline ""
  bitfld.long 0 3.--5.   "    T_RWM_COMM            ," " "
  textline ""
  bitfld.long 0 6.--8.   "    T_RWM_GPU             ," " "
  textline ""
  bitfld.long 0 9.--11.  "    T_RWM_VIDEO           ," " "
  textline ""
  bitfld.long 0 12.--14. "    T_SEL_CORTEX_DOLPHIN  ," " "
  textline ""
  bitfld.long 0 15.--17. "    T_SEL_CORTEX_TSMC     ," " "
  textline ""
  bitfld.long 0 21.--23. "    T_RWN_ARM_SYS         ," " "
  textline ""
  bitfld.long 0 24.--26. "    T_RWN_ARM_ROM         ," " "
  textline ""
  bitfld.long 0 27.--29. "    T_RWN_SECURITY_ROM    ," " "
group 0x078--0x07B
 line.long 0 "MIPI_CTL1, MIPI Control Register 1"
  textline ""
  bitfld.long 0  0.--3.  "    SKEW_CNT_LANE0        ," "  "
  textline ""
  bitfld.long 0  4.--7.  "    SKEW_CNT_LANE1        ," "  "
  textline ""
  bitfld.long 0  8.--11. "    SKEW_CNT_CLK          ," "  "
  textline ""
  bitfld.long 0 12. "    ENABLE_LANE1         ," " 0, 1 "
  textline ""
  bitfld.long 0 13. "    ENABLE_LANE0         ," " 0, 1 "
  textline ""
  bitfld.long 0 14. "    ENABLE_CLK           ," " 0, 1 "
  textline ""
  bitfld.long 0 15. "    ENABLE_LANE1_TERM    ," " 0, 1 "
  textline ""
  bitfld.long 0 16. "    ENABLE_LANE0_TERM    ," " 0, 1 "
  textline ""
  bitfld.long 0 17. "    ENABLE_CLK_TERM      ," " 0, 1 "
  textline ""
  bitfld.long 0 18. "    ENABLE_LANE1_HS      ," " 0, 1 "
  textline ""
  bitfld.long 0 19. "    ENABLE_LANE0_HS      ," " 0, 1 "
  textline ""
  bitfld.long 0 20. "    ENABLE_CLK_HS        ," " 0, 1 "
  textline ""
  bitfld.long 0 21. "    DESER_PRESET_N       ," " 0, 1 "
  textline ""
  bitfld.long 0 22. "    MIPI_SW_CTL          ," " 0, 1 "
  textline ""
  bitfld.long 0 23.--26. "    MIPI_ANATEST1         ," "  "
  textline ""
  bitfld.long 0 27.--30. "    MIPI_ANATEST2         ," "  "
  textline ""
  bitfld.long 0 31. "    MIPI_SPARE           ," " 0, 1 "
group 0x07C--0x07F
 line.long 0 "MIPI_CTL2, MIPI Control Register 2"
  textline ""
  bitfld.long 0 0.--3.   "    MIPI_BIAS_LANE0       ," "  "
  textline ""
  bitfld.long 0 4.--7.   "    MIPI_BIAS_LANE1       ," "  "
  textline ""
  bitfld.long 0 8.--11.  "    MIPI_BIAS_CLK         ," "  "
  textline ""
  hexmask.long 0 12.--31. 1 "    MIPI_SPARE            ,"
rgroup 0x080--0x083
 line.long 0 "SA_SIG, Security Accelerator Signaling Register"
  textline ""
  bitfld.long 0  0.--7.  "    SA_DS_VIOL            ," "  "
  textline ""
  bitfld.long 0  8.--15. "    SA_PS_VIOL            ," "  "
  textline ""
  bitfld.long 0 16.      "    SA_HIRQ              ," " 0, 1 "
  textline ""
  bitfld.long 0 17.      "    EFUSE_Q3_NZ          ," " 0, 1 "
  textline ""
  bitfld.long 0 18.      "    EFUSE_Q2_NZ          ," " 0, 1 "
  textline ""
  bitfld.long 0 19.      "    EFUSE_Q1_NZ          ," " 0, 1 "
  textline ""
  bitfld.long 0 20.      "    EFUSE_Q0_NZ          ," " 0, 1 "
  textline ""
  bitfld.long 0 21.      "    BUS MONITOR0 ENABLE  ," " 0, 1 "
  textline ""
  bitfld.long 0 22.      "    BUS MONITOR1 ENABLE  ," " 0, 1 "
rgroup 0x084--0x087
 line.long 0 "SA_MON1, Security Accelerator Monitor Register 1"
rgroup 0x088--0x08B
 line.long 0 "SA_MON2, Security Accelerator Monitor Register 2"
rgroup 0x08C--0x08F
 line.long 0 "SA_EFUSE_LCS, Security Accelerator EFUSE LCS Register "
rgroup 0x090--0x093
 line.long 0 "SA_EFUSE_SW_VER, Security Accelerator Software Version Register"
rgroup 0x094--0x097
 line.long 0 "SA_EFUSE_DID, Security Accelerator Device ID Register"
rgroup 0x098--0x09B
 line.long 0 "SA_DCU, Security Accelerator Debug Visibility"
rgroup 0x09C--0x09F
 line.long 0 "SA_LCS, Security Accelerator Life Cycle control bus"
  textline ""
  bitfld.long 0  0.--7. "    SA_LCS                ," "  "
  textline ""
  bitfld.long 0  8. "    SA_RMA               ," " 0, 1 "
  textline ""
  bitfld.long 0  9. "    SA_IS_SECURE         ," " 0, 1 "
  textline ""
  bitfld.long 0 10. "    SA_DM                ," " 0, 1 "
  textline ""
  bitfld.long 0 11. "    SA_CM                ," " 0, 1 "
  textline ""
  bitfld.long 0 12.--15. "    CALC_EFUSE_LCS        ," " "
rgroup 0x0A0--0x0A3
 line.long 0 "EFUSE_CTL_STATE, EFUSE Controller State Register"
  textline ""
  bitfld.long 0  0.--3.  "    EFUSE_FSM_STATE       ," "  "
  textline ""
  bitfld.long 0 30.      "    FUSE_AIB_READY       ," " 0, 1 "
  textline ""
  bitfld.long 0 31.      "    FUSE_AIB_PROG_COMPL  ," " 0, 1 "
rgroup 0x0A4--0x0A7
 line.long 0 "EFUSE_RESERVED, EFUSE Reversed Bits Register"
group 0x0A8--0x0AB
 line.long 0 "MEMBIST_CTRL, Memory BIST Control Register"
  textline ""
  bitfld.long 0  0.      "    MBIST_EN             ," " disabled, enabled "
group 0x0AC--0x0AF
 line.long 0 "WIFI_MBIST_CFG, WIFI Memory BIST Configuration Register"
  textline ""
  bitfld.long 0  0.  "    OFDM_MBIST_MEMGROUPSEL     ," " 0, 1 "
  textline ""
  bitfld.long 0  1.  "    OFDM_MBIST_BISTMODE        ," " 0, 1 "
  textline ""
  bitfld.long 0  8.  "    CCK_MBIST_MEMGROUPSEL      ," " 0, 1 "
  textline ""
  bitfld.long 0  9.  "    CCK_MBIST_BISTMODE         ," " 0, 1 "
  textline ""
  bitfld.long 0 16.  "    WIFI_MAC_MBIST_MEMGROUPSEL ," " 0, 1 "
  textline ""
  bitfld.long 0 17.  "    WIFI_MAC_MBIST_BISTMODE    ," " 0, 1 "
  textline ""
  bitfld.long 0 29.  "    OFDM_MBIST_FINISH          ," " 0, 1 "
  textline ""
  bitfld.long 0 30.  "    CCK_MBIST_FINISH           ," " 0, 1 "
  textline ""
  bitfld.long 0 31.  "    WIFI_MAC_MBIST_FINISH      ," " 0, 1 "
rgroup 0x0B0--0x0B3
 line.long 0 "WIFI_MBIST_STAT1, WIFI BIST Status Register 1"
rgroup 0x0B4--0x0B7
 line.long 0 "WIFI_MBIST_STAT2, WIFI BIST Status Register 2"
group 0x0B8--0x0BB
 line.long 0 "ARM9_MBIST_CTRL, ARM9 Memory BIST Control and Status Register 2"
group 0x0BC--0x0BF
 line.long 0 "ARM_SYS_MBIST_CT, ARM Sys Memory BIST Control and Status Register 2"
group 0x0C0--0x0C3
 line.long 0 "MS_MBIST_CTRL, Memory-stick Memory BIST Control and Status Register 2"
group 0x0C4--0x0C7
 line.long 0 "OSDM_MBIST_CTRL, OSDM Memory BIST Control and Status Register 2"
group 0x0C8--0x0CB
 line.long 0 "MBIST1_CTRL, Group1 BIST Control and Status Register 1"
group 0x0CC--0x0CF
 line.long 0 "MBIST2_CTRL, Group1 BIST Control and Status Register 2"
group 0x0D0--0x0D3
 line.long 0 "MBIST3_CTRL, Group1 BIST Control and Status Register 2"
group 0x0D4--0x0D7
 line.long 0 "MBIST4_CTRL, Group1 BIST Control and Status Register 2"
group 0x0D8--0x0DB
 line.long 0 "MCU_ROMBIST_CTRL, MCU ROM BIST Control and Status Register"
rgroup 0x0DC--0x0DF
 line.long 0 "MCU_ROMBIST_SIG0, MCU ROM BIST First ROM Signature"
rgroup 0x0E0--0x0E3
 line.long 0 "MCU_ROMBIST_SIG1, MCU ROM BIST Second ROM Signature"
group 0x0E4--0x0E7
 line.long 0 "CC_ROMBIST, CryptoCore ROM BIST Control and Status Register"
rgroup 0x0E8--0x0EB
 line.long 0 "CC_ROMBIST_SIG0, CryptoCore ROM BIST First ROM Signature"
rgroup 0x0EC--0x0EF
 line.long 0 "CC_ROMBIST_SIG1, CryptoCore ROM BIST Second ROM Signature"
group 0x0F0--0x0F3
 line.long 0 "HANTRO_ROMBIST, HANTRO ROM BIST Control and Status Register"
rgroup 0x0F4--0x0F7
 line.long 0 "HANTRO_ROMB_SIG0, HANTRO ROM BIST 1st ROM Signature"
rgroup 0x0F8--0x0FB
 line.long 0 "HANTRO_ROMB_SIG1, HANTRO ROM BIST 2nd ROM Signature"
rgroup 0x0FC--0x0FF
 line.long 0 "HANTRO_ROMB_SIG2, HANTRO ROM BIST 3rd ROM Signature"
rgroup 0x100--0x103
 line.long 0 "HANTRO_ROMB_SIG3, HANTRO ROM BIST 4th ROM Signature"
rgroup 0x104--0x107
 line.long 0 "HANTRO_ROMB_SIG4, HANTRO ROM BIST 5th ROM Signature"
rgroup 0x108--0x10B
 line.long 0 "HANTRO_ROMB_SIG5, HANTRO ROM BIST 6th ROM Signature"
group 0x10C--0x10F
 line.long 0 "VIVANTE_MEMBIST, VIVANTE Memory BIST COnfiguration Register"
rgroup 0x110--0x113
 line.long 0 "VIV_MBIST_FAIL0, VIVANTE BIST Fail Status Register 0"
rgroup 0x114--0x117
 line.long 0 "VIV_MBIST_FAIL1, VIVANTE BIST Fail Status Register 1"
group 0x118--0x11B
 line.long 0 "HANTRO_ENC_MBIST, HANTRO ENC Memory BIST Configuration Register"
group 0x11C--0x11F
 line.long 0 "HANTRO_DEC_MBIST, HANTRO DEC Memory BIST Configuration Register"
group 0x130--0x133
 line.long 0 "DRAMCTL_CFG0, DRAMCTL Configuration Register 0"
group 0x134--0x137
 line.long 0 "DRAMCTL_CFG1, DRAMCTL Configuration Register 1"
group 0x138--0x13B
 line.long 0 "DRAMCTL_CFG2, DRAMCTL Configuration Register 2"
group 0x13C--0x13F
 line.long 0 "DRAMCTL_CFG3, DRAMCTL Configuration Register 3"
group 0x140--0x143
 line.long 0 "DRAMCTL_CFG4, DRAMCTL Configuration Register 4"
tree.end

;=====================================================
tree "TDM      - Time Division Multiplex"
;=====================================================
;-----------------------------------------------------
tree "TDM1"
;-----------------------------------------------------
base a:0x05f00000
group 0x000--0x001
 line.word 0 "TDM_ENABLE"
  bitfld.word 0 0. " TDM_EN ," " 0, 1 "
group 0x004--0x005
 line.word 0 "TDM_CONFIG_1"
  textline ""
  hexmask.word 0  0.--4. 1 "    TIME_SLOTS  ,"
  textline ""
  bitfld.word 0  8. "    TX_EDGE    ," " transmitted data is launched at the rising edge of SCLK, transmitted data is launched at the falling edge of SCLK "
  textline ""
  bitfld.word 0  9. "    RX_EDGE    ," " received data is sampled at the rising edge of SCLK, received data is sampled at the falling edge of SCLK "
  textline ""
  bitfld.word 0 10. "    SYNC_EDGE  ," " FSYNC signal is generated from SCLK rising edge, FSYNC signal is generated from SCLK falling edge "
  textline ""
  bitfld.word 0 11. "    FSYNC_MSTR_SLV ," " external,fsync "
  textline ""
  bitfld.word 0 12. "    CLK_MSTR_SLV   ," " external,serial clock "
  textline ""
  bitfld.word 0 13. "    AUTO_SYNC ," " no resync,rsync "
group 0x008--0x009
 line.word 0 "TDM_CONFIG_2"
  textline ""
  bitfld.word 0 0.--2. "    BANK_SIZE  ," " 2 FIFO lines/ 64 banks, 4 FIFO lines / 32 banks, 8 FIFO lines / 16 banks, 16 FIFO lines / 8 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks "
  textline ""
  bitfld.word 0 8. "    TRUNCATE   ," " only the upper N bits (N = the value in DATA_WIDTH field) are transmitted/contain the received bit stream, only the lower N bits are transmitted/contain the received bit stream "
  textline ""
  bitfld.word 0 9. "    SHIFT      ," " serial data is shifted LSB first, the serial data is shifted MSB first "
group 0x00C--0x00D
 line.word 0 "TDM_CYCLE"
  textline ""
  bitfld.word 0 0.--1. "    BIT_CYCLE (the number of SCLK cycles per bit equals BIT_CYCLE+1)                    ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 4.--5. "    TX_CYCLE (the SCLK cycle that launches the transmitted data is TX_CYCLE+1)          ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 8.--9. "    RX_CYCLE (the SCLK cycle that the received data is sampled at equals to RX_CYCLE+1) ," " 0, 1, 2, 3 "
group 0x010--0x011
 line.word 0 "TDM_FSYNC"
  textline ""
  hexmask.word 0 0.--4. 1 "    FSYNC_TIME_SLOT ,"
  textline ""
  hexmask.word 0 8.--12. 1 "    FSYNC_BIT       ,"
group 0x014--0x015
 line.word 0 "TDM_FSYNC_DUR"
  textline ""
  hexmask.word 0 0.--9. 1 "    FSYNC_DUR (the duration (in SCLK cycles) of the FSYNC signal highlevel in master mode is set to FSYNC_DUR+1)"
group 0x018--0x019
 line.word 0 "TDM_FIFO_WM"
  textline ""
  hexmask.word 0 0.--5.  1 "    TX_LVL "
  textline ""
  hexmask.word 0 8.--13. 1 "    RX_LVL "
wgroup 0x01C--0x01D
 hide.word 0 "FIFO_BNK_CNTL"
  textline ""
  bitfld.word 0 0. "    TX_FIFO_BNK_INC ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_FIFO_BNK_INC ," " 0, 1 "
group 0x020--0x021
 line.word 0 "TDM_INT_EN"
  textline ""
  bitfld.word 0 0. "    TX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 1. "    TX_EMPTY_INT_EN ," " disabled, enabled "
  textline ""
  bitfld.word 0 2. "    RX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 3. "    RX_FULL_INT_EN  ," " disabled, enabled "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT_EN    ," " disabled, enabled "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT_EN ," " disabled, enabled "
group 0x024--0x025
 line.word 0 "TDM_TF_INT_MSK"
wgroup 0x028--0x029
 hide.word 0 "TDM_INT_CLR"
  textline ""
  bitfld.word 0 0. "    TX_UNDRN_INT_CLR ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_OVRN_INT_CLR  ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    FSYNC_INT_CLR    ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    TX_FLAGS_INT_CLR ," " 0, 1 "
rgroup 0x02C--0x02D
 line.word 0 "TDM_INT_STATUS"
  textline ""
  bitfld.word 0 0. "    TX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    TX_UNDRN_INT ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    RX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    RX_OVRN_INT  ," " 0, 1 "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT    ," " 0, 1 "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT ," " 0, 1 "
group 0x030--0x031
 line.word 0 "TDM_STATUS"
  textline ""
  hexmask.word 0 0.--6.  1 "    TX_EMPTY_BNKS ,"
  textline ""
  hexmask.word 0 8.--14. 1 "    RX_FULL_BNKS  ,"
rgroup 0x034--0x035
 line.word 0 "TDM_TX_FLAGS"
wgroup 0x038--0x039
 hide.word 0 "TDM_TX_FIFO"
rgroup 0x03C--0x03D
 line.word 0 "TDM_RX_FIFO"
;TDM Transmit Registers Array 0x05F0 0A00 through 0x05F0 0A3C
;TDM Receive Registers Array 0x05F0 1200 through 0x05F0 123C
;TDM Frame Descriptors Array 0x05F0 1800 through 0x05F0 187C
tree.end

;-----------------------------------------------------
tree "TDM2"
;-----------------------------------------------------
base a:0x06000000
group 0x000--0x001
 line.word 0 "TDM_ENABLE"
  bitfld.word 0 0. " TDM_EN ," " 0, 1 "
group 0x004--0x005
 line.word 0 "TDM_CONFIG_1"
  textline ""
  hexmask.word 0  0.--4. 1 "    TIME_SLOTS  ,"
  textline ""
  bitfld.word 0  8. "    TX_EDGE    ," " transmitted data is launched at the rising edge of SCLK, transmitted data is launched at the falling edge of SCLK "
  textline ""
  bitfld.word 0  9. "    RX_EDGE    ," " received data is sampled at the rising edge of SCLK, received data is sampled at the falling edge of SCLK "
  textline ""
  bitfld.word 0 10. "    SYNC_EDGE  ," " FSYNC signal is generated from SCLK rising edge, FSYNC signal is generated from SCLK falling edge "
  textline ""
  bitfld.word 0 11. "    FSYNC_MSTR_SLV ," " external,fsync "
  textline ""
  bitfld.word 0 12. "    CLK_MSTR_SLV   ," " external,serial clock "
  textline ""
  bitfld.word 0 13. "    AUTO_SYNC ," " no resync,rsync "
group 0x008--0x009
 line.word 0 "TDM_CONFIG_2"
  textline ""
  bitfld.word 0 0.--2. "    BANK_SIZE  ," " 2 FIFO lines/ 64 banks, 4 FIFO lines / 32 banks, 8 FIFO lines / 16 banks, 16 FIFO lines / 8 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks "
  textline ""
  bitfld.word 0 8. "    TRUNCATE   ," " only the upper N bits (N = the value in DATA_WIDTH field) are transmitted/contain the received bit stream, only the lower N bits are transmitted/contain the received bit stream "
  textline ""
  bitfld.word 0 9. "    SHIFT      ," " serial data is shifted LSB first, the serial data is shifted MSB first "
group 0x00C--0x00D
 line.word 0 "TDM_CYCLE"
  textline ""
  bitfld.word 0 0.--1. "    BIT_CYCLE (the number of SCLK cycles per bit equals BIT_CYCLE+1)                    ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 4.--5. "    TX_CYCLE (the SCLK cycle that launches the transmitted data is TX_CYCLE+1)          ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 8.--9. "    RX_CYCLE (the SCLK cycle that the received data is sampled at equals to RX_CYCLE+1) ," " 0, 1, 2, 3 "
group 0x010--0x011
 line.word 0 "TDM_FSYNC"
  textline ""
  hexmask.word 0 0.--4. 1 "    FSYNC_TIME_SLOT ,"
  textline ""
  hexmask.word 0 8.--12. 1 "    FSYNC_BIT       ,"
group 0x014--0x015
 line.word 0 "TDM_FSYNC_DUR"
  textline ""
  hexmask.word 0 0.--9. 1 "    FSYNC_DUR (the duration (in SCLK cycles) of the FSYNC signal highlevel in master mode is set to FSYNC_DUR+1)"
group 0x018--0x019
 line.word 0 "TDM_FIFO_WM"
  textline ""
  hexmask.word 0 0.--5.  1 "    TX_LVL "
  textline ""
  hexmask.word 0 8.--13. 1 "    RX_LVL "
wgroup 0x01C--0x01D
 hide.word 0 "FIFO_BNK_CNTL"
  textline ""
  bitfld.word 0 0. "    TX_FIFO_BNK_INC ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_FIFO_BNK_INC ," " 0, 1 "
group 0x020--0x021
 line.word 0 "TDM_INT_EN"
  textline ""
  bitfld.word 0 0. "    TX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 1. "    TX_EMPTY_INT_EN ," " disabled, enabled "
  textline ""
  bitfld.word 0 2. "    RX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 3. "    RX_FULL_INT_EN  ," " disabled, enabled "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT_EN    ," " disabled, enabled "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT_EN ," " disabled, enabled "
group 0x024--0x025
 line.word 0 "TDM_TF_INT_MSK"
wgroup 0x028--0x029
 hide.word 0 "TDM_INT_CLR"
  textline ""
  bitfld.word 0 0. "    TX_UNDRN_INT_CLR ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_OVRN_INT_CLR  ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    FSYNC_INT_CLR    ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    TX_FLAGS_INT_CLR ," " 0, 1 "
rgroup 0x02C--0x02D
 line.word 0 "TDM_INT_STATUS"
  textline ""
  bitfld.word 0 0. "    TX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    TX_UNDRN_INT ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    RX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    RX_OVRN_INT  ," " 0, 1 "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT    ," " 0, 1 "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT ," " 0, 1 "
group 0x030--0x031
 line.word 0 "TDM_STATUS"
  textline ""
  hexmask.word 0 0.--6.  1 "    TX_EMPTY_BNKS ,"
  textline ""
  hexmask.word 0 8.--14. 1 "    RX_FULL_BNKS  ,"
rgroup 0x034--0x035
 line.word 0 "TDM_TX_FLAGS"
wgroup 0x038--0x039
 hide.word 0 "TDM_TX_FIFO"
rgroup 0x03C--0x03D
 line.word 0 "TDM_RX_FIFO"
;TDM Transmit Registers Array 0x05F0 0A00 through 0x05F0 0A3C
;TDM Receive Registers Array 0x05F0 1200 through 0x05F0 123C
;TDM Frame Descriptors Array 0x05F0 1800 through 0x05F0 187C
tree.end

;-----------------------------------------------------
tree "TDM3"
;-----------------------------------------------------
base a:0x06100000
group 0x000--0x001
 line.word 0 "TDM_ENABLE"
  bitfld.word 0 0. " TDM_EN ," " 0, 1 "
group 0x004--0x005
 line.word 0 "TDM_CONFIG_1"
  textline ""
  hexmask.word 0  0.--4. 1 "    TIME_SLOTS  ,"
  textline ""
  bitfld.word 0  8. "    TX_EDGE    ," " transmitted data is launched at the rising edge of SCLK, transmitted data is launched at the falling edge of SCLK "
  textline ""
  bitfld.word 0  9. "    RX_EDGE    ," " received data is sampled at the rising edge of SCLK, received data is sampled at the falling edge of SCLK "
  textline ""
  bitfld.word 0 10. "    SYNC_EDGE  ," " FSYNC signal is generated from SCLK rising edge, FSYNC signal is generated from SCLK falling edge "
  textline ""
  bitfld.word 0 11. "    FSYNC_MSTR_SLV ," " external,fsync "
  textline ""
  bitfld.word 0 12. "    CLK_MSTR_SLV   ," " external,serial clock "
  textline ""
  bitfld.word 0 13. "    AUTO_SYNC ," " no resync,rsync "
group 0x008--0x009
 line.word 0 "TDM_CONFIG_2"
  textline ""
  bitfld.word 0 0.--2. "    BANK_SIZE  ," " 2 FIFO lines/ 64 banks, 4 FIFO lines / 32 banks, 8 FIFO lines / 16 banks, 16 FIFO lines / 8 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks "
  textline ""
  bitfld.word 0 8. "    TRUNCATE   ," " only the upper N bits (N = the value in DATA_WIDTH field) are transmitted/contain the received bit stream, only the lower N bits are transmitted/contain the received bit stream "
  textline ""
  bitfld.word 0 9. "    SHIFT      ," " serial data is shifted LSB first, the serial data is shifted MSB first "
group 0x00C--0x00D
 line.word 0 "TDM_CYCLE"
  textline ""
  bitfld.word 0 0.--1. "    BIT_CYCLE (the number of SCLK cycles per bit equals BIT_CYCLE+1)                    ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 4.--5. "    TX_CYCLE (the SCLK cycle that launches the transmitted data is TX_CYCLE+1)          ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 8.--9. "    RX_CYCLE (the SCLK cycle that the received data is sampled at equals to RX_CYCLE+1) ," " 0, 1, 2, 3 "
group 0x010--0x011
 line.word 0 "TDM_FSYNC"
  textline ""
  hexmask.word 0 0.--4. 1 "    FSYNC_TIME_SLOT ,"
  textline ""
  hexmask.word 0 8.--12. 1 "    FSYNC_BIT       ,"
group 0x014--0x015
 line.word 0 "TDM_FSYNC_DUR"
  textline ""
  hexmask.word 0 0.--9. 1 "    FSYNC_DUR (the duration (in SCLK cycles) of the FSYNC signal highlevel in master mode is set to FSYNC_DUR+1)"
group 0x018--0x019
 line.word 0 "TDM_FIFO_WM"
  textline ""
  hexmask.word 0 0.--5.  1 "    TX_LVL "
  textline ""
  hexmask.word 0 8.--13. 1 "    RX_LVL "
wgroup 0x01C--0x01D
 hide.word 0 "FIFO_BNK_CNTL"
  textline ""
  bitfld.word 0 0. "    TX_FIFO_BNK_INC ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_FIFO_BNK_INC ," " 0, 1 "
group 0x020--0x021
 line.word 0 "TDM_INT_EN"
  textline ""
  bitfld.word 0 0. "    TX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 1. "    TX_EMPTY_INT_EN ," " disabled, enabled "
  textline ""
  bitfld.word 0 2. "    RX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 3. "    RX_FULL_INT_EN  ," " disabled, enabled "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT_EN    ," " disabled, enabled "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT_EN ," " disabled, enabled "
group 0x024--0x025
 line.word 0 "TDM_TF_INT_MSK"
wgroup 0x028--0x029
 hide.word 0 "TDM_INT_CLR"
  textline ""
  bitfld.word 0 0. "    TX_UNDRN_INT_CLR ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_OVRN_INT_CLR  ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    FSYNC_INT_CLR    ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    TX_FLAGS_INT_CLR ," " 0, 1 "
rgroup 0x02C--0x02D
 line.word 0 "TDM_INT_STATUS"
  textline ""
  bitfld.word 0 0. "    TX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    TX_UNDRN_INT ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    RX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    RX_OVRN_INT  ," " 0, 1 "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT    ," " 0, 1 "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT ," " 0, 1 "
group 0x030--0x031
 line.word 0 "TDM_STATUS"
  textline ""
  hexmask.word 0 0.--6.  1 "    TX_EMPTY_BNKS ,"
  textline ""
  hexmask.word 0 8.--14. 1 "    RX_FULL_BNKS  ,"
rgroup 0x034--0x035
 line.word 0 "TDM_TX_FLAGS"
wgroup 0x038--0x039
 hide.word 0 "TDM_TX_FIFO"
rgroup 0x03C--0x03D
 line.word 0 "TDM_RX_FIFO"
;TDM Transmit Registers Array 0x05F0 0A00 through 0x05F0 0A3C
;TDM Receive Registers Array 0x05F0 1200 through 0x05F0 123C
;TDM Frame Descriptors Array 0x05F0 1800 through 0x05F0 187C
tree.end
tree.end

;=====================================================
tree "TMR      - General Purpose Timers"
;=====================================================
;-----------------------------------------------------
tree "Timer 1"
;-----------------------------------------------------
base a:0x05800000
group 0x000--0x003
 line.long 0 "TMR1LOAD"
rgroup 0x004--0x007
 line.long 0 "TMR1VALUE"
group 0x008--0x00B
 line.long 0 "TMR1CONTROL"
  textline ""
  bitfld.long 0 7. "    Timer Enable     ," " disabled, enabled "
  textline ""
  bitfld.long 0 6. "    Timer Mode       ,"," periodic, free running "
  textline ""
  bitfld.long 0 5. "    Interrupt Enable ,"," disabled, enabled "
  textline ""
  bitfld.long 0 2.--3. "    Prescale bits     ,","0 stages (clock is divided by 1), 4 stages (clock is divided by 16), 8 stages (clock is divided by 256), undefined (do not use)"
  textline ""
  bitfld.long 0 1. "    Timer Size       ,"," 16-bit counter, 32-bit counter "
  textline ""
  bitfld.long 0 0. "    One Shot Count   ,"," wrapping mode, one-shot mode "
wgroup 0x00C--0x00F
 hide.long 0 "TMR1INTCLR"
rgroup 0x010--0x013
 line.long 0 "TMR1RIS"
rgroup 0x014--0x017
 line.long 0 "TMR1MIS"
group 0x018--0x01B
 line.long 0 "TMR1BGLOAD"
tree.end

;-----------------------------------------------------
tree "Timer 2"
;-----------------------------------------------------
group 0x020--0x023
 line.long 0 "TMR2LOAD"
rgroup 0x024--0x027
 line.long 0 "TMR2VALUE"
group 0x028--0x02B
 line.long 0 "TMR2CONTROL"
  textline ""
  bitfld.long 0 7. "    Timer Enable     ," " disabled, enabled "
  textline ""
  bitfld.long 0 6. "    Timer Mode       ,"," periodic, free running "
  textline ""
  bitfld.long 0 5. "    Interrupt Enable ,"," disabled, enabled "
  textline ""
  bitfld.long 0 2.--3. "    Prescale bits     ,","0 stages (clock is divided by 1), 4 stages (clock is divided by 16), 8 stages (clock is divided by 256), undefined (do not use)"
  textline ""
  bitfld.long 0 1. "    Timer Size       ,"," 16-bit counter, 32-bit counter "
  textline ""
  bitfld.long 0 0. "    One Shot Count   ,"," wrapping mode, one-shot mode "
wgroup 0x02C--0x02F
 hide.long 0 "TMR2INTCLR"
rgroup 0x030--0x033
 line.long 0 "TMR2RIS"
rgroup 0x034--0x037
 line.long 0 "TMR2MIS"
group 0x038--0x03B
 line.long 0 "TMR2BGLOAD"
tree.end

;-----------------------------------------------------
tree "Timer 3"
;-----------------------------------------------------
base a:0x05900000
group 0x000--0x003
 line.long 0 "TMR3LOAD"
rgroup 0x004--0x007
 line.long 0 "TMR3VALUE"
group 0x008--0x00B
 line.long 0 "TMR3CONTROL"
  textline ""
  bitfld.long 0 7. "    Timer Enable     ," " disabled, enabled "
  textline ""
  bitfld.long 0 6. "    Timer Mode       ,"," periodic, free running "
  textline ""
  bitfld.long 0 5. "    Interrupt Enable ,"," disabled, enabled "
  textline ""
  bitfld.long 0 2.--3. "    Prescale bits     ,","0 stages (clock is divided by 1), 4 stages (clock is divided by 16), 8 stages (clock is divided by 256), undefined (do not use)"
  textline ""
  bitfld.long 0 1. "    Timer Size       ,"," 16-bit counter, 32-bit counter "
  textline ""
  bitfld.long 0 0. "    One Shot Count   ,"," wrapping mode, one-shot mode "
wgroup 0x00C--0x00F
 hide.long 0 "TMR3INTCLR"
rgroup 0x010--0x013
 line.long 0 "TMR3RIS"
rgroup 0x014--0x017
 line.long 0 "TMR3MIS"
group 0x018--0x01B
 line.long 0 "TMR3BGLOAD"
tree.end

;-----------------------------------------------------
tree "Timer 4"
;-----------------------------------------------------
group 0x020--0x023
 line.long 0 "TMR4LOAD"
rgroup 0x024--0x027
 line.long 0 "TMR4VALUE"
group 0x028--0x02B
 line.long 0 "TMR4CONTROL"
  textline ""
  bitfld.long 0 7. "    Timer Enable     ," " disabled, enabled "
  textline ""
  bitfld.long 0 6. "    Timer Mode       ,"," periodic, free running "
  textline ""
  bitfld.long 0 5. "    Interrupt Enable ,"," disabled, enabled "
  textline ""
  bitfld.long 0 2.--3. "    Prescale bits     ,","0 stages (clock is divided by 1), 4 stages (clock is divided by 16), 8 stages (clock is divided by 256), undefined (do not use)"
  textline ""
  bitfld.long 0 1. "    Timer Size       ,"," 16-bit counter, 32-bit counter "
  textline ""
  bitfld.long 0 0. "    One Shot Count   ,"," wrapping mode, one-shot mode "
wgroup 0x02C--0x02F
 hide.long 0 "TMR4INTCLR"
rgroup 0x030--0x033
 line.long 0 "TMR4RIS"
rgroup 0x034--0x037
 line.long 0 "TMR4MIS"
group 0x038--0x03B
 line.long 0 "TMR4BGLOAD"
tree.end
tree.end

;=====================================================
tree "UART     - UART Block"
;=====================================================
;-----------------------------------------------------
tree "UART1"
;-----------------------------------------------------
base a:0x05a00000
group 0x000--0x001
 line.word 0 "CTL, Control register"
  textline ""
  bitfld.word 0  0. "    UART_EN       ,"," 0, 1 "
group 0x004--0x005
 line.word 0 "CFG, Configuration register"
  textline ""
  bitfld.word 0 15. "    IRDA_UART     ,"," UART data format, IRDA data format "
  textline ""
  bitfld.word 0 14. "    IRDA_DRX_INV  ,"," data in not inverted, data in inverted "
  textline ""
  bitfld.word 0 13. "    IRDA_DTX_INV  ,"," data out not inverted, data in inverted "
  textline ""
  bitfld.word 0 11. "    BREAK_EN      ,"," break detection logic disabled, break detection logic enabled "
  textline ""
  bitfld.word 0 10. "    CTSN_EN       ,"," CTSN flow control disabled, CTSN flow control enabled "
  textline ""
  bitfld.word 0  9. "    RTSN_EN       ,"," RTSN flow control disabled, RTSN flow control enabled "
  textline ""
  bitfld.word 0  8. "    OD_EN         ,"," transmit line is regular output, transmit line is open drained "
  textline ""
  bitfld.word 0  7. "    SW_RST        ,"," flush RX and TX state and FIFO logic "
  textline ""
  bitfld.word 0  6. "    PAR_EN        ,"," no parity enabled, parity selected "
  textline ""
  bitfld.word 0  5. "    PAR_OD_EVEN   ,"," parity is even, parity is odd "
  textline ""
  bitfld.word 0  4. "    STOP_CFG      ,"," one stop bit selected, two stop bits selected "
  textline ""
  bitfld.word 0  2.--3. "    DATA_LENGTH   ,"," 8 bits, 7 bits, 9 bits, 8 bits "
group 0x008--0x009
 line.word 0 "INT_DIV, Integer Divider register"
  textline ""
  hexmask.word 0  0.--15.  1 "    INT_RATE       ,"
group 0x00C--0x00D
 line.word 0 "FRAC_DIV, Fractional Divider register"
  textline ""
  hexmask.word 0  0.--3.  1 "    INT_RATE       ,"
group 0x010--0x011
line.byte 0 "TX_FIFO_WM, TX FIFO Watermark register"
group 0x014--0x015
 line.byte 0 "RX_FIFO_WM, RX FIFO Watermark register"
rgroup 0x018--0x019
 line.word 0 "FIFO_INTSTAT, Interrupt Status register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
group 0x01C--0x01D
 line.word 0 "FIFO_INTEN, Interrupt Enable register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
wgroup 0x020--0x021
 hide.word 0 "FIFO_INT_CLR, Interrupt Clear register"
rgroup 0x024--0x025
 line.byte 0 "TX_FIFO_LVL, TX FIFO Level register"
rgroup 0x028--0x029
 line.byte 0 "RX_FIFO_LVL, RX FIFO Level register"
wgroup 0x02C--0x02D
 hide.word 0 "TX_DAT, TX Data register"
rgroup 0x030--0x031
 hide.word 0 "RX_DAT, RX Data register"
  in
rgroup 0x034--0x035
 line.word 0 "STAT, Status register"
  textline ""
  bitfld.word 0 9. "    RX_FULL  ,"," 0, 1 "
  bitfld.word 0 8. "    RX_EMPTY  ,"," 0, 1 "
  bitfld.word 0 3. "    CTS  ,"," 0, 1 "
  bitfld.word 0 2. "    RTS  ,"," 0, 1 "
  bitfld.word 0 1. "    TX_FULL  ,"," 0, 1 "
  bitfld.word 0 0. "    TX_EMPTY ,"," 0, 1 "
tree.end

;-----------------------------------------------------
tree "UART2"
;-----------------------------------------------------
base a:0x05b00000
group 0x000--0x001
 line.word 0 "CTL, Control register"
  textline ""
  bitfld.word 0  0. "    UART_EN       ,"," 0, 1 "
group 0x004--0x005
 line.word 0 "CFG, Configuration register"
  textline ""
  bitfld.word 0 15. "    IRDA_UART     ,"," UART data format, IRDA data format "
  textline ""
  bitfld.word 0 14. "    IRDA_DRX_INV  ,"," data in not inverted, data in inverted "
  textline ""
  bitfld.word 0 13. "    IRDA_DTX_INV  ,"," data out not inverted, data in inverted "
  textline ""
  bitfld.word 0 11. "    BREAK_EN      ,"," break detection logic disabled, break detection logic enabled "
  textline ""
  bitfld.word 0 10. "    CTSN_EN       ,"," CTSN flow control disabled, CTSN flow control enabled "
  textline ""
  bitfld.word 0  9. "    RTSN_EN       ,"," RTSN flow control disabled, RTSN flow control enabled "
  textline ""
  bitfld.word 0  8. "    OD_EN         ,"," transmit line is regular output, transmit line is open drained "
  textline ""
  bitfld.word 0  7. "    SW_RST        ,"," flush RX and TX state and FIFO logic "
  textline ""
  bitfld.word 0  6. "    PAR_EN        ,"," no parity enabled, parity selected "
  textline ""
  bitfld.word 0  5. "    PAR_OD_EVEN   ,"," parity is even, parity is odd "
  textline ""
  bitfld.word 0  4. "    STOP_CFG      ,"," one stop bit selected, two stop bits selected "
  textline ""
  bitfld.word 0  2.--3. "    DATA_LENGTH   ,"," 8 bits, 7 bits, 9 bits, 8 bits "
group 0x008--0x009
 line.word 0 "INT_DIV, Integer Divider register"
  textline ""
  hexmask.word 0  0.--15.  1 "    INT_RATE       ,"
group 0x00C--0x00D
 line.word 0 "FRAC_DIV, Fractional Divider register"
  textline ""
  hexmask.word 0  0.--3.  1 "    INT_RATE       ,"
group 0x010--0x011
line.byte 0 "TX_FIFO_WM, TX FIFO Watermark register"
group 0x014--0x015
 line.byte 0 "RX_FIFO_WM, RX FIFO Watermark register"
rgroup 0x018--0x019
 line.word 0 "FIFO_INTSTAT, Interrupt Status register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
group 0x01C--0x01D
 line.word 0 "FIFO_INTEN, Interrupt Enable register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
wgroup 0x020--0x021
 hide.word 0 "FIFO_INT_CLR, Interrupt Clear register"
rgroup 0x024--0x025
 line.byte 0 "TX_FIFO_LVL, TX FIFO Level register"
rgroup 0x028--0x029
 line.byte 0 "RX_FIFO_LVL, RX FIFO Level register"
wgroup 0x02C--0x02D
 hide.word 0 "TX_DAT, TX Data register"
rgroup 0x030--0x031
 hide.word 0 "RX_DAT, RX Data register"
  in
rgroup 0x034--0x035
 line.word 0 "STAT, Status register"
  textline ""
  bitfld.word 0 9. "    RX_FULL  ,"," 0, 1 "
  bitfld.word 0 8. "    RX_EMPTY  ,"," 0, 1 "
  bitfld.word 0 3. "    CTS  ,"," 0, 1 "
  bitfld.word 0 2. "    RTS  ,"," 0, 1 "
  bitfld.word 0 1. "    TX_FULL  ,"," 0, 1 "
  bitfld.word 0 0. "    TX_EMPTY ,"," 0, 1 "
tree.end

;-----------------------------------------------------
tree "UART3"
;-----------------------------------------------------
base a:0x05c00000
group 0x000--0x001
 line.word 0 "CTL, Control register"
  textline ""
  bitfld.word 0  0. "    UART_EN       ,"," 0, 1 "
group 0x004--0x005
 line.word 0 "CFG, Configuration register"
  textline ""
  bitfld.word 0 15. "    IRDA_UART     ,"," UART data format, IRDA data format "
  textline ""
  bitfld.word 0 14. "    IRDA_DRX_INV  ,"," data in not inverted, data in inverted "
  textline ""
  bitfld.word 0 13. "    IRDA_DTX_INV  ,"," data out not inverted, data in inverted "
  textline ""
  bitfld.word 0 11. "    BREAK_EN      ,"," break detection logic disabled, break detection logic enabled "
  textline ""
  bitfld.word 0 10. "    CTSN_EN       ,"," CTSN flow control disabled, CTSN flow control enabled "
  textline ""
  bitfld.word 0  9. "    RTSN_EN       ,"," RTSN flow control disabled, RTSN flow control enabled "
  textline ""
  bitfld.word 0  8. "    OD_EN         ,"," transmit line is regular output, transmit line is open drained "
  textline ""
  bitfld.word 0  7. "    SW_RST        ,"," flush RX and TX state and FIFO logic "
  textline ""
  bitfld.word 0  6. "    PAR_EN        ,"," no parity enabled, parity selected "
  textline ""
  bitfld.word 0  5. "    PAR_OD_EVEN   ,"," parity is even, parity is odd "
  textline ""
  bitfld.word 0  4. "    STOP_CFG      ,"," one stop bit selected, two stop bits selected "
  textline ""
  bitfld.word 0  2.--3. "    DATA_LENGTH   ,"," 8 bits, 7 bits, 9 bits, 8 bits "
group 0x008--0x009
 line.word 0 "INT_DIV, Integer Divider register"
  textline ""
  hexmask.word 0  0.--15.  1 "    INT_RATE       ,"
group 0x00C--0x00D
 line.word 0 "FRAC_DIV, Fractional Divider register"
  textline ""
  hexmask.word 0  0.--3.  1 "    INT_RATE       ,"
group 0x010--0x011
line.byte 0 "TX_FIFO_WM, TX FIFO Watermark register"
group 0x014--0x015
 line.byte 0 "RX_FIFO_WM, RX FIFO Watermark register"
rgroup 0x018--0x019
 line.word 0 "FIFO_INTSTAT, Interrupt Status register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
group 0x01C--0x01D
 line.word 0 "FIFO_INTEN, Interrupt Enable register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
wgroup 0x020--0x021
 hide.word 0 "FIFO_INT_CLR, Interrupt Clear register"
rgroup 0x024--0x025
 line.byte 0 "TX_FIFO_LVL, TX FIFO Level register"
rgroup 0x028--0x029
 line.byte 0 "RX_FIFO_LVL, RX FIFO Level register"
wgroup 0x02C--0x02D
 hide.word 0 "TX_DAT, TX Data register"
rgroup 0x030--0x031
 hide.word 0 "RX_DAT, RX Data register"
  in
rgroup 0x034--0x035
 line.word 0 "STAT, Status register"
  textline ""
  bitfld.word 0 9. "    RX_FULL  ,"," 0, 1 "
  bitfld.word 0 8. "    RX_EMPTY  ,"," 0, 1 "
  bitfld.word 0 3. "    CTS  ,"," 0, 1 "
  bitfld.word 0 2. "    RTS  ,"," 0, 1 "
  bitfld.word 0 1. "    TX_FULL  ,"," 0, 1 "
  bitfld.word 0 0. "    TX_EMPTY ,"," 0, 1 "
tree.end
tree.end

;=====================================================
tree "USB      - DWC OTG USB"
;=====================================================
base a:0x00300000
group 0x000--0xFFF

  line.long 0x000 "GOTGCTL, Control and Status Register"
    textfld ":"
    bitfld.long 0x000 27. "  ChirpEn  ,Chirp On Enable" "0    ,1    "
    bitfld.long 0x000 20. "  OTGVer   ,OTG Version" "1.3 ,2.0 "
    bitfld.long 0x000 19. "  BSesVld  ,B-Session Valid" "0,1"
    bitfld.long 0x000 18. "  ASesVld     ,A-Session Valid" "0,1"
    textline "                          "
    bitfld.long 0x000 17. "  DbncTime ,Long/Short Debounce Time" "100ms,2.5us"
    bitfld.long 0x000 16. "  ConIDSts ,Connector ID Status" "A   ,B   "
    bitfld.long 0x000 11. "  DevHNPEn ,Device HNP Enabled" "0,1"
    bitfld.long 0x000 10. "  HstSetHNPEn ,Host Set HNP Enable" "0,1"
    textline "                          "
    bitfld.long 0x000 9. "  HNPReq    ,HNP Request" "0    ,1    "
    bitfld.long 0x000 8. "  HstNegScs ,Host Negotiation Success" "fail,succ"
    bitfld.long 0x000 1. "  SesReq    ,Session Request" "0,1"
    bitfld.long 0x000 0. "  SesReqScs    ,Session Request Success" "fail,succ"
  line.long 0x004 "GOTGINT, Interrupt Register"
    textfld ":"
    eventfld.long 0x004 20. "  MVInpChg         ,Multi-Valued input changed" "0,1"
    eventfld.long 0x004 19. "  DbnceDone        ,Debounce Done" "0,1"
    eventfld.long 0x004 18. "  ADevTOUTChg ,A-Device Timeout Change" "0,1"
    eventfld.long 0x004 17. "  HstNegDet ,Host Negotiation Detected" "0,1"
    textline "                          "
    eventfld.long 0x004 9.  "  HstNegSucStsChng ,Host Negotiation Success Status Change" "0,1"
    eventfld.long 0x004 8.  "  SesReqSucStsChng ,Session Request Success Status Change" "0,1"
    eventfld.long 0x004 2.  "  SesEndDet   ,Session End Detected" "0,1"
  line.long 0x008 "GAHBCFG, AHB Configuration Register"
    textfld ":"
    bitfld.long 0x008 22.    "  NotiAllDmaWrit ,Notify All Dma Write Transactions" "0,1"
    bitfld.long 0x008 21.    "  RemMemSupp ,Remote Memory Support" "0,1"
    bitfld.long 0x008 8.     "  PTxFEmpLvl  ,Periodic TxFIFO Empty Level" "0,1"
    bitfld.long 0x008 7.     "  NPTxFEmpLvl ,Non-Periodic TxFIFO Empty Level" "0,1"
    textline "                          "
    bitfld.long 0x008 5.     "  DMAEn          ,DMA Enable" "0,1"
    bitfld.long 0x008 1.--4. "  HBstLen    ,Burst Length/Type" "Single,INCR,-,INCR4,-,INCR8,-,INCR16,-,-,-,-,-,-,-,-"
    bitfld.long 0x008 0.     "  GlblIntrMsk ,Global Interrupt Mask" "0,1"
  line.long 0x00C "GUSBCFG, USB Configuration Register"
    textfld ":"
    bitfld.long 0x00C 30. "  ForceDevMode   ,Force Device Mode" "0,1"
    bitfld.long 0x00C 29. "  ForceHstMode         ,Force Host Mode" "0,1"
    bitfld.long 0x00C 28. "  TxEndDelay     ,Tx End Delay" "0    ,1    "
    bitfld.long 0x00C 27. "  IC_USBTrafCtl  ,IC_USB TrafficPullRemove Control" "0,1"
    textline "                          "
    bitfld.long 0x00C 26. "  IC_USBCap      ,IC_USB-Capable" "0,1"
    bitfld.long 0x00C 25. "  ULPIDis              ,ULPI Interface Protect Disable" "0,1"
    bitfld.long 0x00C 24. "  IndPassThr     ,Indicator Pass Through" "0    ,1    "
    bitfld.long 0x00C 23. "  IndCompl       ,Indicator Complement" "0,1"
    textline "                          "
    bitfld.long 0x00C 22. "  TermSelDLPulse ,TermSel DLine Pulsing Selection" "0,1"
    bitfld.long 0x00C 21. "  ULPIExtVbusIndicator ,ULPI External VBUS Indicator" "0,1"
    bitfld.long 0x00C 20. "  ULPIExtVbusDrv ,ULPI External VBUS Drive" "0    ,1    "
    bitfld.long 0x00C 19. "  ULPIClkSusM    ,ULPI Clock SuspendM" "0,1"
    textline "                          "
    bitfld.long 0x00C 18. "  ULPIAutoRes    ,ULPI Auto Resume" "0,1"
    bitfld.long 0x00C 17. "  ULPIFsLs             ,ULPI FS/LS Select" "0,1"
    bitfld.long 0x00C 16. "  OtgI2CSel      ,UTMIFS or I2C Interface Select" "0    ,1    "
    bitfld.long 0x00C 15. "  PhyLPwrClkSel  ,PHY Low-Power Clock Select" "internal,external"
    textline "                          "
    hexmask.long.byte 0x00C 10.--13. 1 "  USBTrdTim     ,USB Turnaround Time"
    bitfld.long 0x00C 9.  "  HNPCap               ,HNP-Capable" "0,1"
    bitfld.long 0x00C 8.  "  SRPCap         ,SRP-Capable" "0    ,1    "
    bitfld.long 0x00C 7.  "  DDRSel         ,ULPI DDR Select" "SDR,DDR"
    textline "                          "
    bitfld.long 0x00C 6.  "  PHYSel         ,USB 2.0 High-Speed PHY or USB 1.1 Full-Speed Serial Transceiver Select" "0,1"
    bitfld.long 0x00C 5.  "  FSIntf               ,Full-Speed Serial Interface Select" "0,1"
    bitfld.long 0x00C 4.  "  ULPI_UTMI_Sel  ,ULPI or UTMI+ Select" "UTMI+,ULPI"
    bitfld.long 0x00C 3.  "  PHYIf          ,PHY Interface" "8bits,16bits"
    textline "                          "
    bitfld.long 0x00C 0.--2. "  TOutCal        ,HS/FS Timeout Calibration" "0,1,2,3"
  line.long 0x010 "GRSTCTL, Reset Register"
  line.long 0x014 "GINTSTS, Interrupt Register"
  line.long 0x018 "GINTMSK, Interrupt Mask Register"
  line.long 0x01C "GRXSTSR, Receive Status Debug Read Register"
    textfld ":  Host:"
    bitfld.long 0x01C 17.--20. "  PktSts ,Packet Status" "-,-,IN data,IN complete,-,ToggleErr,-,Halted,-,-,-,-,-,-,-,-"
    bitfld.long 0x01C 15.--16. "  DPID ,Data PID" "DATA0,DATA1,DATA2,MDATA"
    hexmask.long.word 0x01C 4.--14. 1 "  BCnt ,Byte Count"
    hexmask.long.byte 0x01C 0.--3. 1 "  ChNum ,Channel Number"
    textline "                            Dev: "
    hexmask.long.byte 0x01C 21.--24. 1 "  FN ,Frame Number"
    bitfld.long 0x01C 17.--20. "  PktSts ,Packet Status" "-,OUT NAK,OUT Rcv,OUT Compl,SETUP Compl,-,SETUP Recv,-,-,-,-,-,-,-,-,-"
    bitfld.long 0x01C 15.--16. "  DPID ,Data PID"  "DATA0,DATA1,DATA2,MDATA"
    hexmask.long.word 0x01C 4.--14. 1 "  BCnt ,Byte Count"
    hexmask.long.byte 0x01C 0.--3. 1 "  EPNum ,Endpoint Number"
  hide.long 0x020 "GRXSTSP, Receive Status Read and Pop Register"
    in
  line.long 0x024 "GRXFSIZ, Receive FIFO Size Register"
  line.long 0x028 "GNPTXFSIZ, Non-Periodic Transmit FIFO Size Register"
  line.long 0x02C "GNPTXSTS, Non-Periodic Transmit FIFO/Queue Status Register"
  line.long 0x030 "GI2CCTL, I2C Access Register"
  line.long 0x034 "GPVNDCTL, PHY Vendor Control Register"
  line.long 0x038 "GGPIO, General Purpose Input/Output Register"
  line.long 0x03C "GUID, User ID Register"
  line.long 0x040 "GSNPSID, Synopsys ID Register"
  line.long 0x044 "GHWCFG1, User HW Config1 Register"
  line.long 0x048 "GHWCFG2, User HW Config2 Register"
  line.long 0x04C "GHWCFG3, User HW Config3 Register"
  line.long 0x050 "GHWCFG4, User HW Config4 Register"
  line.long 0x054 "GLPMCFG, Core LPM Configuration Register"
  line.long 0x058 "GPWRDN , Global Power Down Register"
  line.long 0x05C "GDFIFOCFG, Global DFIFO Software Config Register"
  line.long 0x060 "GADPCTL, ADP Timer, Control and Status Register"
  line.long 0x100 "HPTXFSIZ, Host Periodic Transmit FIFO Size Register"

  textline ""
  line.long 0xe00 "PCGCCTL, Power and Clock Gating Control Register"
    textfld ":"
    bitfld.long 0xe00 8. "  ResAfterSusp  ,Reset After Suspend" "0,1"
    bitfld.long 0xe00 7. "  L1Suspended ,Deep Sleep" "0,1"
    bitfld.long 0xe00 6. "  PhySleep ,PHY in Sleep" "0,1"
    bitfld.long 0xe00 5. "  Enbl_L1Gating ,Enable Sleep Clock Gating" "0,1"
    textline "                          "
    bitfld.long 0xe00 3. "  RstPdwnModule ,Reset Power-Down Modules" "0,1"
    bitfld.long 0xe00 2. "  PwrClmp     ,Power Clamp" "0,1"
    bitfld.long 0xe00 1. "  GateHclk ,Gate Hclk" "0,1"
    bitfld.long 0xe00 0. "  StopPclk      ,Stop Pclk" "0,1"

  tree.close "Device FIFO Sizes"
  group 0x100--0x13F
    line.long 0x004 "DPTXFSIZ0, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x004 "DIEPTXF0, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x008 "DPTXFSIZ1, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x008 "DIEPTXF1, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x00c "DPTXFSIZ2, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x00c "DIEPTXF2, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x010 "DPTXFSIZ3, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x010 "DIEPTXF3, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x014 "DPTXFSIZ4, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x014 "DIEPTXF4, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x018 "DPTXFSIZ5, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x018 "DIEPTXF5, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x01c "DPTXFSIZ6, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x01c "DIEPTXF6, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x020 "DPTXFSIZ7, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x020 "DIEPTXF7, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x024 "DPTXFSIZ8, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x024 "DIEPTXF8, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x028 "DPTXFSIZ9, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x028 "DIEPTXF9, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x02c "DPTXFSIZ10, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x02c "DIEPTXF10, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x030 "DPTXFSIZ11, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x030 "DIEPTXF11, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x034 "DPTXFSIZ12, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x034 "DIEPTXF12, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x038 "DPTXFSIZ13, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x038 "DIEPTXF13, Device IN Endpoint Transmit FIFO Size Register"
    line.long 0x03c "DPTXFSIZ14, Device Periodic Transmit FIFO-n Size Register"
    line.long 0x03c "DIEPTXF14, Device IN Endpoint Transmit FIFO Size Register"
  tree.end

  tree.close "Device Mode Registers"
  group 0x000--0xBFF
    line.long 0x800 "DCFG, Device Configuration Register"
      textfld ":"
      hexmask.long.byte 0x800 26.--31. 1 "  ResValid ,Resume Validation Period"
      bitfld.long 0x800 24.--25. "  PerSchIntvl ,Periodic Scheduling Interval" "25%,50%,75%,-"
      bitfld.long 0x800 23. "  DescDMA ,Enable Scatter/Gather DMA in Device mode", "  0,  1"
      hexmask.long.byte 0x800 18.--22. 1 "  EPMisCnt ,IN Endpoint Mismatch Count"
      textline "                          "
      bitfld.long 0x800 11.--12. "  PerFrInt ,Periodic Frame Interval" "80%,85%,90%,95%"
      hexmask.long.byte 0x800 4.--10. 1 "  DevAddr ,Device Address"
      bitfld.long 0x800 3. "  Ena32KHzS ,Enable 32-KHz Suspend Mode" "  0,  1"
      bitfld.long 0x800 2. "  NZStsOUTHShk ,Non-Zero-Length Status OUT Handshake" "  0,  1"
      textline "                          "
      bitfld.long 0x800 0.--1. "  DevSpd ,Device Speed" "High (USB2.0 Phy),Full (USB2.0 Phy),-,Full (USB1.1 Phy)"
    line.long 0x804 "DCTL, Device Control Register"
      textfld ":"
      bitfld.long 0x804 16.      "  NakOnBble ,Set NAK automatically on babble" "0,1"
      bitfld.long 0x804 15.      "  IgnrFrmNum ,Ignore frame number for isochronous endpoints in case of Scatter/Gather DMA" "0,1"
      bitfld.long 0x804 13.--14. "  GMC ,Global Multi Count" "-,1,2,3"
      bitfld.long 0x804 11.      "  PWROnPrgDone ,Power-On Programming Done", "0,1"
      textline "                          "
      bitfld.long 0x804 4.--6.   "  TstCtl ,Test Control" "disable,Test_J,Test_K,SE0_NAK,Test_Packet,Test_Force,-,-"
      bitfld.long 0x804 3.       "  GOUTNakSts ,Global OUT NAK Status" "0,1"
      bitfld.long 0x804 2.       "  GNPINNakSts ,Global Non-periodic IN NAK Status" "0,1"
      bitfld.long 0x804 1.       "  SftDiscon ,Soft Disconnect" "connect,disconnect"
      textline "                          "
      bitfld.long 0x804 0.       "  RmtWkUpSig ,Remote Wakeup Signaling" "0,1"
    line.long 0x808 "DSTS, Device Status Register"
      textfld ":"
      hexmask.long.word 0x808 8.--21. 1 "  SOFFN ,Frame or Microframe Number of the Received SOF"
      bitfld.long 0x808 3. "  ErrticErr ,Erratic Error" "0,1"
      bitfld.long 0x808 1.--2. "  EnumSpd ,Enumerated Speed" "High,Full,Low,Full"
      bitfld.long 0x808 0. "  SuspSts ,Suspend Status" "0,1"
    line.long 0x810 "DIEPMSK, Device IN Endpoint Common Interrupt Mask Register"
    line.long 0x814 "DOEPMSK, Device OUT Endpoint Common Interrupt Mask Register"
    line.long 0x818 "DAINT, Device All Endpoints Interrupt Register"
    line.long 0x81C "DAINTMSK, Device All Endpoints Interrupt Mask Register"
    ;line.long 0x820 "DTKNQR1, Device IN Token Sequence Learning Queue Read Register 1"
    ;line.long 0x824 "DTKNQR2, Device IN Token Sequence Learning Queue Read Register 2"
    ;line.long 0x830 "DTKNQR3, Device IN Token Sequence Learning Queue Read Register 3"
    ;line.long 0x834 "DTKNQR4, Device IN Token Sequence Learning Queue Read Register 4"
    line.long 0x828 "DVBUSDIS, Device VBUS Discharge Time Register"
    line.long 0x82C "DVBUSPULSE, Device VBUS Pulsing Time Register"
    line.long 0x830 "DTHRCTL, Device Threshold Control Register"
    line.long 0x834 "DIEPEMPMSK, Device IN Endpoint FIFO Empty Interrupt Mask Register"
    line.long 0x838 "DEACHINT, Device Each Endpoint Interrupt Register"
    line.long 0x83C "DEACHINTMSK, Device Each Endpoint Interrupt Register Mask"
    line.long 0x840 "DIEPEACHMSKn, Device Each In Endpoint-n Interrupt Register"
    line.long 0x880 "DOEPEACHMSKn, Device Each Out Endpoint-n Interrupt Register"
    line.long 0x900 "DIEPCTL0, Device Control IN Endpoint 0 Control Register"
    line.long 0x908 "DIEPINTn, Device Endpoint-n Interrupt Register"
    line.long 0x910 "DIEPTSIZ0, Device Endpoint 0 Transfer Size Register"
      bitfld.long 0x910 19.--20. ":  PktCnt ,Packet Count" "0,1,2,3"
      hexmask.long.byte 0x910 0.--6. 1 "  XferSize ,Transfer Size"
    line.long 0x910 "DIEPTSIZn, Device Endpoint-n Transfer Size Register"
    line.long 0x914 "DIEPDMAn, Device Endpoint-n DMA Address Register"
    line.long 0x918 "DTXFSTSn , Device IN Endpoint Transmit FIFO Status Register"
    line.long 0x91C "DIEPDMAB0, Device Endpoint-n DMA Buffer Address Register "
    line.long 0x93C "DIEPDMABn, Device Endpoint-n DMA Buffer Address Register "
    line.long 0x920 "DIEPCTLn, Device Endpoint-n Control Register"
    line.long 0xB00 "DOEPCTL0, Device Control OUT Endpoint 0 Control Register"
      bitfld.long 0x800 31. ":  EPEna ,Endpoint Enable" "0,1"
      bitfld.long 0x800 21. "  Stall ,STALL Handshake" "0,1"
      bitfld.long 0x800 20. "  Snp ,Snoop Mode" "0,1"
      bitfld.long 0x800 17. "  NAKSts ,NAK Status" "0,1"
      bitfld.long 0x800 0.--1. "  MPS ,Maximum Packet Size" "64,32,16,8"
    line.long 0xB08 "DOEPINTn, Device Endpoint-n Interrupt Register"
    line.long 0xB10 "DOEPTSIZ0, Device Endpoint 0 Transfer Size Register"
      bitfld.long 0xB10 29.--30. ":  SUPCnt ,SETUP Packet Count" "0,1,2,3"
      bitfld.long 0xB10 19.--20. "  PktCnt ,Packet Count" "0,1,2,3"
      hexmask.long.byte 0xB10 0.--6. 1 "  XferSize ,Transfer Size"
    line.long 0xB10 "DOEPTSIZn, Device Endpoint-n Transfer Size Register"
    line.long 0xB14 "DOEPDMAn, Device Endpoint-n DMA Address Register"
    line.long 0xB1C "DOEPDMAB0, Device Endpoint-n DMA Buffer Address Register "
    line.long 0xB20 "DOEPCTLn, Device Endpoint-n Control Register"
  tree.end

  tree.close "Host Mode Registers"
  group 0x000--0xBFF
    line.long 0x400 "HCFG, Host Configuration Register"
    line.long 0x404 "HFIR, Host Frame Interval Register"
    line.long 0x408 "HFNUM, Host Frame Number/Frame Time Remaining Register"
    line.long 0x410 "HPTXSTS, Host Periodic Transmit FIFO/Queue Status Register"
    line.long 0x414 "HAINT, Host All Channels Interrupt Register"
    line.long 0x418 "HAINTMSK, Host All Channels Interrupt Mask Register"
    line.long 0x440 "HPRT, Host Port Control and Status Register"
      bitfld.long 0x440 11. ":  D- " "0,1"
      bitfld.long 0x440 10. "  D+ " "0,1"
  tree.end

textline ""
group 0x1000--0x1003
  hide.long 0x00 "DFIFO0"
    in
group 0x2000--0x2003
  hide.long 0x00 "DFIFO1"
    in
group 0x3000--0x3003
  hide.long 0x00 "DFIFO2"
    in
group 0x4000--0x4003
  hide.long 0x00 "DFIFO3"
    in
group 0x5000--0x5003
  hide.long 0x00 "DFIFO4"
    in
group 0x6000--0x6003
  hide.long 0x00 "DFIFO5"
    in
group 0x7000--0x7003
  hide.long 0x00 "DFIFO6"
    in
group 0x8000--0x8003
  hide.long 0x00 "DFIFO7"
    in
group 0x9000--0x9003
  hide.long 0x00 "DFIFO8"
    in
group 0xa000--0xa003
  hide.long 0x00 "DFIFO9"
    in
group 0xb000--0xb003
  hide.long 0x00 "DFIFO10"
    in
group 0xc000--0xc003
  hide.long 0x00 "DFIFO11"
    in
group 0xd000--0xd003
  hide.long 0x00 "DFIFO12"
    in
group 0xe000--0xe003
  hide.long 0x00 "DFIFO13"
    in
group 0xf000--0xf003
  hide.long 0x00 "DFIFO14"
    in
group 0x10000--0x10003
  hide.long 0x00 "DFIFO15"
    in
tree.end

;=====================================================
tree "WATCHDOG - Watchdog Timer"
;=====================================================
base a:0x05700000
group 0x000--0x001
 line.word 0 "WDCTRL, Watchdog Control Register"
  textline ""
  bitfld.word 0 2. "    WDINTEN       ," " 0, 1 "
  bitfld.word 0 0.--1. " WDPERIOD  ," " 1s, 10s, 100s, 1000s "
wgroup 0x004--0x005
 hide.word 0 "WDEN, Watchdog Enable Register"
group 0x008--0x009
 line.word 0 "WDREFR, Watchdog Refresh Register"
group 0x01C--0x01D
 line.word 0 "WDINTCLR, Watchdog Interrupt Clear Register"
  textline ""
  bitfld.word 0 0. "    WD_INT_CLR    ," " 0, 1 "
rgroup 0x020--0x021
 line.word 0 "WDINTSTAT, Watchdog Interrupt Status Register"
  textline ""
  bitfld.word 0 0. "    WD_INT_STAT   ," " 0, 1 "
tree.end



