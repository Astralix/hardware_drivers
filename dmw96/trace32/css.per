base a:0x0
group 00--00
textline " +-----------------------------------------------------------------+"
textline " | Lauterbach peripheral file for DMW96 (CSS)                      |"
textline " | (c) 2010 DSPG Technologies GmbH                                 |"
textline " | Version 1.0                                                     |"
textline " +-----------------------------------------------------------------+"

config 16. 8.
width  16. 8.

;=====================================================
tree "SYSCFG   - System Configuration"
;=====================================================
base a:0x05200000
rgroup 0x000--0x003
 line.long 0 "GCR0, General Control Register 0"
group 0x004--0x007
 line.long 0 "GCR1, General Control Register 1"
  textline ""
  bitfld.long 0 0.--1. "    ROMWS                ," " no wait states,1 wait states,2 wait states,3 wait states "
  textline ""
  bitfld.long 0 2.     "    CSS_INIT_RAM         ," " AHB RAM, ITCM "
rgroup 0x008--0x00B
 line.long 0 "GCR2, General Control Register 2"
rgroup 0x00C--0x00F
 line.long 0 "CORTEX_IR, Cortex Interrupts Register"
  textline ""
  bitfld.long 0 0. "    DMASIRQ              ," " not active, active "
  textline ""
  bitfld.long 0 1. "    DMAIRQ               ," " not active, active "
  textline ""
  bitfld.long 0 2. "    DMAEXTERRIRQ         ," " not active, active "
wgroup 0x010--0x012
 hide.long 0 "CORTEX_ICLR, Cortex Interrupts Register"
rgroup 0x013--0x017
 line.long 0 "SYSOPT_CFG, System Configuration Options Register"
  textline ""
  bitfld.long 0  0. "    DIS_CSS              ," " enabled,disabled "
  textline ""
  bitfld.long 0  1. "    DIS_VIDEO_DECODER    ," " enabled,disabled "
  textline ""
  bitfld.long 0  2. "    DIS_H264_DECODE      ," " enabled,disabled "
  textline ""
  bitfld.long 0  3. "    DIS_MPEG4_H.263      ," " enabled,disabled "
  textline ""
  bitfld.long 0  4. "    DIS_MPEG2_MPEG1      ," " enabled,disabled "
  textline ""
  bitfld.long 0  5. "    DIS_SORENSON_SPARK   ," " enabled,disabled "
  textline ""
  bitfld.long 0  6. "    DIS_JPEG             ," " enabled,disabled "
  textline ""
  bitfld.long 0  7. "    DIS_VCI              ," " enabled,disabled "
  textline ""
  bitfld.long 0  8. "    DIS_DIVX             ," " enabled,disabled "
  textline ""
  bitfld.long 0  9. "    DIS_RV               ," " enabled,disabled "
  textline ""
  bitfld.long 0 10. "    DIS_VP6              ," " enabled,disabled "
  textline ""
  bitfld.long 0 11. "    DIS_1080P            ," " enabled,disabled "
  textline ""
  bitfld.long 0 12. "    DIS_720P             ," " enabled,disabled "
  textline ""
  bitfld.long 0 13. "    DIS_DI               ," " enabled,disabled "
  textline ""
  bitfld.long 0 14. "    DIS_CIF              ," " enabled,disabled "
  textline ""
  bitfld.long 0 15. "    DIS_REFERENCE_BUFFER ," " enabled,disabled "
  textline ""
  bitfld.long 0 16. "    DIS_VIDEO_ENCODER    ," " enabled,disabled "
  textline ""
  bitfld.long 0 17. "    DIS_3D_GRAPHICS      ," " enabled,disabled "
  textline ""
  bitfld.long 0 18. "    DIS_SONY_MS          ," " enabled,disabled "
  textline ""
  bitfld.long 0 19. "    EN_SECURE_BOOT       ," " disabled,enabled "
  textline ""
  bitfld.long 0 20.--23. "    PLC                   ," "  "
rgroup 0x018--0x01B
 line.long 0 "CHIP_ID, HW Identification Register"
rgroup 0x01C--0x01F
 line.long 0 "CHIP_REV, HW Revision Register"
group 0x020--0x023
 line.long 0 "BMP_CTL, BMP Control Register"
  textline ""
  bitfld.long 0 0.--2. "    XTALDACFRAC           ," "  "
  textline ""
  bitfld.long 0 3.--8. "    XTALDAC               ," "  "
  textline ""
  bitfld.long 0 10.       "    BCLK_EN              ," " enabled,disabled "
  textline ""
  bitfld.long 0 14.       "    BMP_TB_EN            ," " disabled,enabled "
  textline ""
  bitfld.long 0 15.       "    BMP_DEBUG_EN         ," " disabled,enabled "
rgroup 0x024--0x027
 line.long 0 "SA_SIG, Security Accelerator Signaling Register"
  textline ""
  bitfld.long 0 0. "    SA_HIRQ              ," " 0, 1 "
  textline ""
  bitfld.long 0 1. "    SA_PS_VIOL           ," " 0, 1 "
  textline ""
  bitfld.long 0 2. "    SA_DS_VIOL           ," " 0, 1 "
rgroup 0x028--0x02B
 line.long 0 "SA_MON1, Security Accelerator Monitor Register 1"
rgroup 0x02C--0x02F
 line.long 0 "SA_MON2, Security Accelerator Monitor Register 2"
wgroup 0x030--0x033
 hide.long 0 "TEST_CTRL_EN, Test Control Enable Register"
group 0x034--0x037
 line.long 0 "TEST_CTRL, Test Control Register"
  textline ""
  bitfld.long 0  0. "    USB_PHY_BP           ," " normal,bypassed "
  textline ""
  bitfld.long 0  1. "    USB_SHELL_BP         ," " normal, bypassed "
  textline ""
  bitfld.long 0  2. "    WD_TEST              ," " normal,test mode "
  textline ""
  bitfld.long 0  3. "    ICU_TEST             ," " normal,test mode "
  textline ""
  bitfld.long 0  4. "    RAM_TEST             ," " normal,test mode "
  textline ""
  bitfld.long 0  5. "    DBG_TDM              ," " normal,debug mode "
  textline ""
  bitfld.long 0  6. "    TDM_PROD_TEST        ," " normal,test mode "
  textline ""
  bitfld.long 0  7. "    RTC_DBG_EN           ," " not affected,stopped "
  textline ""
  bitfld.long 0 12. "    IO_IE_LOOPBCK_EN     ," " off,on "
  textline ""
  bitfld.long 0 13. "    DAC_TEST_BUS         ," " 0,1 "
  textline ""
  bitfld.long 0 14. "    ADCA_TEST_BUS        ," " 0,1 "
  textline ""
  bitfld.long 0 15. "    ADCB_TEST_BUS        ," " 0,1 "
group 0x038--0x03B
 line.long 0 "IO_LOC, IO Location Register"
group 0x03C--0x03F
 line.long 0 "ISO_CTL, Isolation Control Register"
  textline ""
  bitfld.long 0  0. "    CSS_ISO              ," " isolated,connected "
  textline ""
  bitfld.long 0  1. "    MM_ISO               ," " isolated,connected "
  textline ""
  bitfld.long 0  2. "    NEON_ISO             ," " isolated,connected "
  textline ""
  bitfld.long 0  3. "    CORESIGHT_ISO        ," " isolated,connected "
group 0x040--0x043
 line.long 0 "POWER_EN, Power Enable Register"
  textline ""
  bitfld.long 0  0. "    CSS_EN               ," " off,on "
  textline ""
  bitfld.long 0  1. "    MM_EN                ," " off,on "
  textline ""
  bitfld.long 0  2. "    NEON_EN              ," " off,on "
  textline ""
  bitfld.long 0  3. "    CORESIGHT_EN         ," " off,on "
rgroup 0x044--0x047
 line.long 0 "POWER_STS, Power Status Register"
  textline ""
  bitfld.long 0  0. "    CSS_READY            ," " off,on "
  textline ""
  bitfld.long 0  1. "    MM_READY             ," " off,on "
  textline ""
  bitfld.long 0  2. "    NEON_READY           ," " off,on "
  textline ""
  bitfld.long 0  3. "    CORESIGHT_READY      ," " off,on "
tree.end

;=====================================================
tree "CMU      - Clock Management Unit"
;=====================================================
base a:0x05300000
group 0x000--0x003
 line.long 0 "PLL1CONTROL"
  textline ""
  bitfld.long 0  0.--4.    "    PLL1R                 ," "  "
  textline ""
  bitfld.long 0  5.--11.   "    PLL1F                 ," "  "
  textline ""
  bitfld.long 0 12.--13.   "    PLL1OD                ," "1,2,4,8"
  textline ""
  bitfld.long 0 14.        "    PLL1BS                ," "low band,high band"
  textline ""
  bitfld.long 0 15.        "    PLL1PD                ," "active,power-down"
  textline ""
  bitfld.long 0 16.        "    PLL1BP                ," "not bypassed,bypass mode"
  textline ""
  bitfld.long 0 17.        "    PLL1ERR               ," "legal,illegal"
  textline ""
  bitfld.long 0 18.        "    PLL1LD                ," "not locked,locked"
  textline ""
  bitfld.long 0 19.--20.   "    PLL1INSRC             ," "12MHz,20MHz,13.824MHz,Reserved"
group 0x004--0x007
 line.long 0 "PLL2CONTROL"
  textline ""
  bitfld.long 0 0.--4.     "    PLL2R                 ," "  "
  textline ""
  bitfld.long 0 5.--11.    "    PLL2F                 ," "  "
  textline ""
  bitfld.long 0 12.--13.   "    PLL2OD                ," "1,2,4,8"
  textline ""
  bitfld.long 0 14.        "    PLL2BS                ," "low band,high band"
  textline ""
  bitfld.long 0 15.        "    PLL2PD                ," "active,power-down"
  textline ""
  bitfld.long 0 16.        "    PLL2BP                ," "not bypassed,bypass mode"
  textline ""
  bitfld.long 0 17.        "    PLL2ERR               ," "legal,illegal"
  textline ""
  bitfld.long 0 18.        "    PLL2LD                ," "not locked,locked"
  textline ""
  bitfld.long 0 19.--20.   "    PLL2INSRC             ," "12MHz,20MHz,13.824MHz,Reserved"
group 0x008--0x00B
 line.long 0 "PLL3CONTROL"
  textline ""
  bitfld.long 0 0.--4.     "    PLL3R                 ," "  "
  textline ""
  bitfld.long 0 5.--11.    "    PLL3F                 ," "  "
  textline ""
  bitfld.long 0 12.--13.   "    PLL3OD                ," "1,2,4,8"
  textline ""
  bitfld.long 0 14.        "    PLL3BS                ," "low band,high band"
  textline ""
  bitfld.long 0 15.        "    PLL3PD                ," "active,power-down"
  textline ""
  bitfld.long 0 16.        "    PLL3BP                ," "not bypassed,bypass mode"
  textline ""
  bitfld.long 0 17.        "    PLL3ERR               ," "legal,illegal"
  textline ""
  bitfld.long 0 18.        "    PLL3LD                ," "not locked,locked"
  textline ""
  bitfld.long 0 19.--20.   "    PLL3INSRC             ," "12MHz,20MHz,13.824MHz,Reserved"
group 0x00C--0x00F
 line.long 0 "PLL4CONTROL"
  textline ""
  bitfld.long 0 0.--4.     "    PLL4R                 ," "  "
  textline ""
  bitfld.long 0 5.--11.    "    PLL4F                 ," "  "
  textline ""
  bitfld.long 0 12.--13.   "    PLL4OD                ," "1,2,4,8"
  textline ""
  bitfld.long 0 14.        "    PLL4BS                ," "low band,high band"
  textline ""
  bitfld.long 0 15.        "    PLL4PD                ," "active,power-down"
  textline ""
  bitfld.long 0 16.        "    PLL4BP                ," "not bypassed,bypass mode"
  textline ""
  bitfld.long 0 17.        "    PLL4ERR               ," "legal,illegal"
  textline ""
  bitfld.long 0 18.        "    PLL4LD                ," "not locked,locked"
  textline ""
  bitfld.long 0 19.--20.   "    PLL4INSRC             ," "12MHz,20MHz,13.824MHz,Reserved"
group 0x010--0x013
 line.long 0 "WIFIPLLCONTROL"
  textline ""
  bitfld.long 0 0.--5.     "    WPLLM                 ," "  "
  textline ""
  bitfld.long 0 6.         "    WPLLBYPASS            ," "normal,bypassed"
  textline ""
  bitfld.long 0 7.         "    WPLLCSSEL             ," "alternative,differential"
  textline ""
  bitfld.long 0 8.         "    WPLLLOCK              ," "unlocked,locked"
group 0x014--0x017
 line.long 0 "CPUCLKCNTRL"
  textline ""
  ;bitfld.long 0 0.--1.     "    CORTEXDIV             ," "1,2,3,4"
  ;textline ""
  ;bitfld.long 0 2.--3.     "    CORTEXAXI             ," "1,2,3,4"
  ;textline ""
  bitfld.long 0 4.--7.     "    SYSBUSDIV             ," "  "
  textline ""
  bitfld.long 0 8.--9.     "    PLL2SWCTL             ," "CPUICLK,PLL2 output,ALTSYSCLK,Reserved"
  textline ""
  bitfld.long 0 12.--13.   "    SYSSRC_NOR            ," "CPUICLK,ALTSYSSRC,PLL1,Reserved"
  textline ""
  bitfld.long 0 14.--15.   "    ALTSYSSRC             ," "12MHz,20MHz,13.824MHz,Reserved"
  textline ""
  bitfld.long 0 16.--17.   "    CPUSRC                ," "12MHz,20MHz,13.824MHz,Reserved"
  textline ""
  bitfld.long 0 18.        "    SYS_AUTO              ," "SW control,low power"
  textline ""
  bitfld.long 0 19.        "    PLL1PD_LP             ," "PLL1 active,PLL1 power-down"
  textline ""
  bitfld.long 0 20.--21.   "    SYSSRC_LP             ," "CPUICLK,ALTSYSSRC,PLL1,Reserved"
group 0x018--0x01B
 line.long 0 "COMCLKSEL"
  textline ""
  bitfld.long 0 0.--3.     "    COMALTDIV             ," "  "
  textline ""
  bitfld.long 0 4.--8.     "    COMADPCMDIV           ," "  "
  textline ""
  bitfld.long 0 9.         "    BMPREFDIV             ," "13.824MHz,13.824MHz/12"
  textline ""
  bitfld.long 0 10.--11.   "    SWCOMSRC              ," "COMALTDIV,PLL4 output,PLL4SRC,Reserved"
  textline ""
  bitfld.long 0 12.--13.   "    COMLPSRC              ," "COMALTDIV,PLL4 output,PLL4SRC,Reserved"
  textline ""
  bitfld.long 0 14.        "    COMLPEN               ," "disabled,enabled"
group 0x01C--0x01F
 line.long 0 "CLKSWCNTRL"
  textline ""
  bitfld.long 0 0.         "    SWDRAMSRC             ," "12MHz,PLL3 output"
  textline ""
  bitfld.long 0 3.         "    SLOWDIV_EN            ," "disabled,enabled" 
  textline ""
  bitfld.long 0 4.--14.    "    SLOWDIVRATE           ," "    "
  textline ""
  bitfld.long 0 15.        "    MII_CLK_SRC           ," "ETHMDIV,off-chip"
  textline ""
  bitfld.long 0 16.        "    SWSLOWSRC             ," "SLOWDIV,32kHz"
  textline ""
  bitfld.long 0 17.--18.   "    LCDDIVSRC             ," "SYSSRC,PLL3,PLL4,Reserved"
  textline ""
  bitfld.long 0 19.--20.   "    TDM1DIVSRC            ," "SYSSRC,PLL3,PLL4,Reserved"
  textline ""
  bitfld.long 0 21.--22.   "    TDM2DIVSRC            ," "SYSSRC,PLL3,PLL4,Reserved"
  textline ""
  bitfld.long 0 23.--24.   "    TDM3DIVSRC            ," "SYSSRC,PLL3,PLL4,Reserved"
  textline ""
  bitfld.long 0 25.        "    ETHRDIVSRC            ," "SYSCLK,PLL4 output"
group 0x020--0x023
 line.long 0 "CLKDIVCNTRL1"
  textline ""
  hexmask.long 0  0.--7.  1 "    CIUDIV                ,"
  textline ""
  hexmask.long 0  8.--15. 1 "    LCDPIXDIV             ,"
  textline ""
  hexmask.long 0 16.--23. 1 "    MSDIV                 ,"
  textline ""
  hexmask.long 0 24.--31. 1 "    SDDIV                 ,"
group 0x024--0x027
 line.long 0 "CLKDIVCNTRL2"
  textline ""
  hexmask.long 0  0.--3.  1 "    VIDEDIV               ,"
  textline ""
  hexmask.long 0  4.--5.  1 "    PLL4ALTSRC            ,"
  textline ""
  hexmask.long 0  8.--15. 1 "    VIDDDIV               ,"
  textline ""
  hexmask.long 0 16.--19. 1 "    GPUDIV                ,"
  textline ""
  hexmask.long 0 20.--23. 1 "    ETHRDIV               ,"
  textline ""
  hexmask.long 0 24.--31. 1 "    PLL4PREDIV            ,"
group 0x028--0x02B
 line.long 0 "CLKDIVCNTRL3"
  textline ""
  hexmask.long 0  0.--7.  1 "    DPDIV                 ,"
  textline ""
  hexmask.long 0  8.--15. 1 "    SIMDIV                ,"
group 0x02C--0x02F
 line.long 0 "CLKDIVCNTRL4"
  textline ""
  hexmask.long 0  0.--11. 1 "    TDM1DIV               ,"
  textline ""
  hexmask.long 0 12.--23. 1 "    TDM2DIV               ,"
group 0x030--0x033
 line.long 0 "CLKDIVCNTRL5"
  textline ""
  hexmask.long 0  0.--11. 1 "    TDM3DIV               ,"
  textline ""
  hexmask.long 0 12.--19. 1 "    CLKOUTDIV             ,"
group 0x034--0x037
 line.long 0 "CLKDIVCNTRL6"
  textline ""
  hexmask.long 0  0.--17. 1 "    MS_DVEN_DIV           ,"
group 0x038--0x03B
 line.long 0 "LPTMRR"
  textline ""
  hexmask.long 0  0.--15. 1 "    BREAKDISTIME          ,"
  textline ""
  hexmask.long 0 16.--19. 1 "    WIFI_PLL_DLY          ,"
  textline ""
  hexmask.long 0 20.--31. 1 "    XTALOKDURATION        ,"
group 0x03C--0x03F
 line.long 0 "CLKOSCCR"
  textline ""
  bitfld.long 0 0.         "    32K_OSC_EN            ," "disabled,enabled"
  textline ""
  bitfld.long 0 1.         "    DECT_OSC_EN           ," "disabled,enabled"
  textline ""
  bitfld.long 0 2.         "    12M_OSC_EN            ," "disabled,enabled"
  textline ""
  bitfld.long 0 3.         "    32K_OSCSTAT           ," "disabled,detected"
  textline ""
  bitfld.long 0 4.         "    DECT_OSCSTAT          ," "disabled,enabled"
  textline ""
  bitfld.long 0 5.         "    USB_OSCSTAT           ," "disabled,detected"
  textline ""
  bitfld.long 0 6.         "    WIFI_XTAL_RDY         ," "not ready,ready"
  textline ""
  hexmask.long 0 8.--11. 1 "    DECT_OSC_CTL          ,"
  textline ""
  hexmask.long 0 12.--15. 1 "    12M_OSC_CTL           ,"
wgroup 0x040--0x043
 hide.long 0 "SWSYSRST"
wgroup 0x044--0x047
 hide.long 0 "SWWRMRST"
group 0x048--0x04B
 line.long 0 "RSTSR"
  textline ""
  bitfld.long 0 2.         "    SLOWSRC_STRAP         ," "SLOWDIV,32K"
  textline ""
  bitfld.long 0 3.         "    WDRSTIND              ," "watchdog reset,no reset"
  textline ""
  bitfld.long 0 4.         "    SWWRMRSTIND           ," "software warm reset,no reset"
  textline ""
  bitfld.long 0 5.         "    SWSYSRSTIND           ," "software full reset,no reset"
  textline ""
  bitfld.long 0 6.--7.     "    CLKO_STRAP            ," "PLL2,CORTEX CPU,System bus,CLKOUTDIV"
  textline ""
  hexmask.long 0 8.--15. 1 "    UCFG                  ,"
  textline ""
  bitfld.long 0 16.        "    BOOT_SRC              ," "NOR flash,ROM"
wgroup 0x04C--0x04F
 hide.long 0 "WRPR"
wgroup 0x050--0x053
 hide.long 0 "SWCHWRST1"
wgroup 0x054--0x057
 hide.long 0 "SWCHWRST2"
group 0x058--0x05B
 line.long 0 "SWCLKENR1"
  textline ""
  bitfld.long 0  0.        "    GDMAC_CLK_EN          ," "0,1"
  textline ""
  bitfld.long 0  1.        "    CSS_ARM926_CLK_EN     ," "0,1"
  textline ""
  bitfld.long 0  2.        "    RTC_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0  3.        "    ETHMAC_CLK_EN         ," "0,1"
  textline ""
  bitfld.long 0  4.        "    SECURE_CLK_EN         ," "0,1"
  textline ""
  bitfld.long 0  5.        "    RMII_IF_CLK_EN        ," "0,1"
  textline ""
  bitfld.long 0  6.        "    UART1_CLK_EN          ," "0,1"
  textline ""
  bitfld.long 0  7.        "    UART2_CLK_EN          ," "0,1"
  textline ""
  bitfld.long 0  8.        "    UART3_CLK_EN          ," "0,1"
  textline ""
  bitfld.long 0  9.        "    TDM1_CLK_EN           ," "0,1"
  textline ""
  bitfld.long 0 10.        "    TDM2_CLK_EN           ," "0,1"
  textline ""
  bitfld.long 0 11.        "    TDM3_CLK_EN           ," "0,1"
  textline ""
  bitfld.long 0 12.        "    MSC_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 13.        "    SDC_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 14.        "    NFC_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 15.        "    ACP_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 16.        "    USB_MAC_CLK_EN        ," "0,1"
  textline ""
  bitfld.long 0 17.        "    USB_PHY_CLK_EN        ," "0,1"
  textline ""
  bitfld.long 0 18.        "    WIFI_CLK_EN           ," "0,1"
  textline ""
  bitfld.long 0 19.        "    CIU_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 20.        "    OSDM_CLK_EN           ," "0,1"
  textline ""
  bitfld.long 0 21.        "    LCDC_CLK_EN           ," "0,1"
  textline ""
  bitfld.long 0 22.        "    SEC_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 23.        "    CSS_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 24.        "    GPU_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 25.        "    VIDDE_CLK_EN          ," "0,1"
  textline ""
  bitfld.long 0 26.        "    VIDEN_CLK_EN          ," "0,1"
  textline ""
  bitfld.long 0 27.        "    SIM_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 28.        "    DP_CLK_EN             ," "0,1"
  textline ""
  bitfld.long 0 29.        "    CSS_ADPCM_CLK_EN      ," "0,1"
  textline ""
  bitfld.long 0 30.        "    CSS_BMP_CLK_EN        ," "0,1"
  textline ""
  bitfld.long 0 31.        "    CSS_ETM_CLK_EN        ," "0,1"
group 0x05C--0x05F
 line.long 0 "SWCLKENR2"
  textline ""
  bitfld.long 0  0.        "    TIMER1_CLK_EN         ," "0,1"
  textline ""
  bitfld.long 0  1.        "    TIMER2_CLK_EN         ," "0,1"
  textline ""
  bitfld.long 0  2.        "    TIMER3_CLK_EN         ," "0,1"
  textline ""
  bitfld.long 0  3.        "    TIMER4_CLK_EN         ," "0,1"
  textline ""
  bitfld.long 0  4.        "    I2C_1_CLK_EN          ," "0,1"
  textline ""
  bitfld.long 0  5.        "    I2C_2_CLK_EN          ," "0,1"
  textline ""
  bitfld.long 0  6.        "    SPI1_CLK_EN           ," "0,1"
  textline ""
  bitfld.long 0  7.        "    SPI2_CLK_EN           ," "0,1"
  textline ""
  bitfld.long 0  8.        "    SLVMII_CLK_EN         ," "0,1"
  textline ""
  bitfld.long 0  9.        "    IR_REMCTL_CLK_EN      ," "0,1"
  textline ""
  bitfld.long 0 10.        "    SMC_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 11.        "    CLKOUT_CLK_EN         ," "0,1"
  textline ""
  bitfld.long 0 12.        "    DRAM_CTL_CLK_EN       ," "0,1"
  textline ""
  bitfld.long 0 13.        "    CSS_TIMER1_CLK_EN     ," "0,1"
  textline ""
  bitfld.long 0 14.        "    CSS_TIMER2_CLK_EN     ," "0,1"
  textline ""
  bitfld.long 0 15.        "    CSS_GDMAC_CLK_EN      ," "0,1"
  textline ""
  bitfld.long 0 16.        "    USB2_MAC_CLK_EN       ," "0,1"
  textline ""
  bitfld.long 0 17.        "    USB2_PHY_CLK_EN       ," "0,1"
  textline ""
  bitfld.long 0 18.        "    DBM_CLK_EN            ," "0,1"
  textline ""
  bitfld.long 0 19.        "    PLL4PREDIV_EN         ," "0,1"
  textline ""
  bitfld.long 0 20.        "    CORESIGHT_CLK_EN      ," "0,1"
rgroup 0x060--0x063
 line.long 0 "CUSTATR"
  textline ""
  bitfld.long 0  0.        "    OSC12M_IN_USE         ," "0,1"
  textline ""
  bitfld.long 0  1.        "    OSC13M_IN_USE         ," "0,1"
  textline ""
  bitfld.long 0  2.        "    CLK20M_IN_USE         ," "0,1"
  textline ""
  bitfld.long 0  3.        "    OSC32K_IN_USE         ," "0,1"
  textline ""
  bitfld.long 0  4.        "    PLL1_IN_USE           ," "0,1"
  textline ""
  bitfld.long 0  5.        "    PLL2_IN_USE           ," "0,1"
  textline ""
  bitfld.long 0  6.        "    PLL3_IN_USE           ," "0,1"
  textline ""
  bitfld.long 0  7.        "    PLL4_IN_USE           ," "0,1"
  textline ""
  bitfld.long 0  8.        "    SYS_SRC_0_IN_USE      ," "0,1"
  textline ""
  bitfld.long 0  9.        "    SYS_SRC_1_IN_USE      ," "0,1"
  textline ""
  bitfld.long 0 10.        "    SYS_SRC_2_IN_USE      ," "0,1"
  textline ""
  bitfld.long 0 11.        "    CPUSRC_IN_USE         ," "0,1"
  textline ""
  bitfld.long 0 12.        "    COM_ALT_IN_USE        ," "0,1"
  textline ""
  bitfld.long 0 13.        "    PLL4SRC_IN_USE        ," "0,1"
  textline ""
  bitfld.long 0 14.        "    DIVSCSLK_IN_USE       ," "0,1"
  textline ""
  bitfld.long 0 15.        "    ALTSYSSRC_IN_USE      ," "0,1"
group 0x064--0x067
 line.long 0 "SWOVRCTL"
  textline ""
  bitfld.long 0 0.         "    SW_OVR_SEL            ," "0,1"
  textline ""
  bitfld.long 0 1.         "    SW_OVR_CTL            ," "0,1"
  textline ""
  bitfld.long 0 2.         "    SW_SYS_20M_OVR_CTL    ," "0,1"
  textline ""
  bitfld.long 0 3.         "    SW_WIFI_OVR_SEL       ," "0,1"
  textline ""
  bitfld.long 0 4.         "    SW_WIFI_OVR_CTL       ," "0,1"
  textline ""
  hexmask.long 0 5.--7. 1  "    WIFI_FSM_STATE        ,"
  textline ""
  bitfld.long 0 8.         "    HW_REQ_20M_STS        ," "0,1"
  textline ""
  bitfld.long 0 9.--10.    "    SWCOMSRC_SEL          ," "COMALTDIV,PLL4 output,PLL4SRC,Reserved"
  textline ""
  bitfld.long 0 11.--12.   "    SYSSRC_SEL            ," "CPISCLK,ALTSYSCLK,PLL1 output,Reserved"
  textline ""
  bitfld.long 0 13.        "    PD_FSM_STATE          ," "PLL1 powered down,PLL1 enabled"
  textline ""
  hexmask.long 0 14.--16. 1 "    HW_REQ_20M_STS        ,"
  textline ""
  bitfld.long 0 17.        "    CLK20M_EN             ," "disabled,enabled"
group 0x068--0x06B
 line.long 0 "CMU_TEST"
  textline ""
  hexmask.long 0 0.--4. 1  "    CLOCK_OUT_SEL         ,"
  textline ""
  bitfld.long 0 8.         "    13M_BP_DIV_4_EN       ," "0,1"
  textline ""
  bitfld.long 0 9.         "    PLL4_BP_DIV_4_EN      ," "0,1"
  textline ""
  bitfld.long 0 10.        "    SYSFSM_BP             ," "0,1"
  textline ""
  bitfld.long 0 11.        "    HW_REQ_20M_CFG        ," "0,1"
  textline ""
  bitfld.long 0 12.        "    ARM_CLK_EN_BP         ," "0,1"
  textline ""
  bitfld.long 0 16.        "    ARM_MCLK_EN           ," "0,1"
  textline ""
  bitfld.long 0 17.        "    ARM_STANDBY_WFI       ," "0,1"
  textline ""
  bitfld.long 0 18.        "    CORTEX_STANDBY_WFI    ," "0,1"
  textline ""
  bitfld.long 0 19.        "    SW500MSRC_CLK2_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 20.        "    SW500MSRC_CLK1_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 21.        "    SW500MSRC_CLK0_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 22.        "    SWSLOWSRC_CLK1_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 23.        "    SWSLOWSRC_CLK0_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 24.        "    SWDRAMSRC_CLK1_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 25.        "    SWDRAMSRC_CLK0_IN_USE ," "0,1"
  textline ""
  bitfld.long 0 26.        "    SWCOMSRC_CLK2_IN_USE  ," "0,1"
  textline ""
  bitfld.long 0 27.        "    SWCOMSRC_CLK1_IN_USE  ," "0,1"
  textline ""
  bitfld.long 0 28.        "    SWCOMSRC_CLK0_IN_USE  ," "0,1"
  textline ""
  bitfld.long 0 29.        "    PLL2SW_CLK2_IN_USE    ," "0,1"
  textline ""
  bitfld.long 0 30.        "    PLL2SW_CLK1_IN_USE    ," "0,1"
  textline ""
  bitfld.long 0 31.        "    PLL2SW_CLK0_IN_USE    ," "0,1"
tree.end

;=====================================================
tree "UART     - UART Block"
;=====================================================
;-----------------------------------------------------
tree "UART1"
;-----------------------------------------------------
base a:0x05a00000
group 0x000--0x001
 line.word 0 "CTL, Control register"
  textline ""
  bitfld.word 0  0. "    UART_EN       ,"," 0, 1 "
group 0x004--0x005
 line.word 0 "CFG, Configuration register"
  textline ""
  bitfld.word 0 15. "    IRDA_UART     ,"," UART data format, IRDA data format "
  textline ""
  bitfld.word 0 14. "    IRDA_DRX_INV  ,"," data in not inverted, data in inverted "
  textline ""
  bitfld.word 0 13. "    IRDA_DTX_INV  ,"," data out not inverted, data in inverted "
  textline ""
  bitfld.word 0 11. "    BREAK_EN      ,"," break detection logic disabled, break detection logic enabled "
  textline ""
  bitfld.word 0 10. "    CTSN_EN       ,"," CTSN flow control disabled, CTSN flow control enabled "
  textline ""
  bitfld.word 0  9. "    RTSN_EN       ,"," RTSN flow control disabled, RTSN flow control enabled "
  textline ""
  bitfld.word 0  8. "    OD_EN         ,"," transmit line is regular output, transmit line is open drained "
  textline ""
  bitfld.word 0  7. "    SW_RST        ,"," flush RX and TX state and FIFO logic "
  textline ""
  bitfld.word 0  6. "    PAR_EN        ,"," no parity enabled, parity selected "
  textline ""
  bitfld.word 0  5. "    PAR_OD_EVEN   ,"," parity is even, parity is odd "
  textline ""
  bitfld.word 0  4. "    STOP_CFG      ,"," one stop bit selected, two stop bits selected "
  textline ""
  bitfld.word 0  2.--3. "    DATA_LENGTH   ,"," 8 bits, 7 bits, 9 bits, 8 bits "
group 0x008--0x009
 line.word 0 "INT_DIV, Integer Divider register"
  textline ""
  hexmask.word 0  0.--15.  1 "    INT_RATE       ,"
group 0x00C--0x00D
 line.word 0 "FRAC_DIV, Fractional Divider register"
  textline ""
  hexmask.word 0  0.--3.  1 "    INT_RATE       ,"
group 0x010--0x011
line.byte 0 "TX_FIFO_WM, TX FIFO Watermark register"
group 0x014--0x015
 line.byte 0 "RX_FIFO_WM, RX FIFO Watermark register"
rgroup 0x018--0x019
 line.word 0 "FIFO_INTSTAT, Interrupt Status register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
group 0x01C--0x01D
 line.word 0 "FIFO_INTEN, Interrupt Enable register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
wgroup 0x020--0x021
 hide.word 0 "FIFO_INT_CLR, Interrupt Clear register"
rgroup 0x024--0x025
 line.byte 0 "TX_FIFO_LVL, TX FIFO Level register"
rgroup 0x028--0x029
 line.byte 0 "RX_FIFO_LVL, RX FIFO Level register"
wgroup 0x02C--0x02D
 hide.word 0 "TX_DAT, TX Data register"
rgroup 0x030--0x031
 hide.word 0 "RX_DAT, RX Data register"
  in
rgroup 0x034--0x035
 line.word 0 "STAT, Status register"
  textline ""
  bitfld.word 0 9. "    RX_FULL  ,"," 0, 1 "
  bitfld.word 0 8. "    RX_EMPTY  ,"," 0, 1 "
  bitfld.word 0 3. "    CTS  ,"," 0, 1 "
  bitfld.word 0 2. "    RTS  ,"," 0, 1 "
  bitfld.word 0 1. "    TX_FULL  ,"," 0, 1 "
  bitfld.word 0 0. "    RX_FULL  ,"," 0, 1 "
tree.end

;-----------------------------------------------------
tree "UART2"
;-----------------------------------------------------
base a:0x05b00000
group 0x000--0x001
 line.word 0 "CTL, Control register"
  textline ""
  bitfld.word 0  0. "    UART_EN       ,"," 0, 1 "
group 0x004--0x005
 line.word 0 "CFG, Configuration register"
  textline ""
  bitfld.word 0 15. "    IRDA_UART     ,"," UART data format, IRDA data format "
  textline ""
  bitfld.word 0 14. "    IRDA_DRX_INV  ,"," data in not inverted, data in inverted "
  textline ""
  bitfld.word 0 13. "    IRDA_DTX_INV  ,"," data out not inverted, data in inverted "
  textline ""
  bitfld.word 0 11. "    BREAK_EN      ,"," break detection logic disabled, break detection logic enabled "
  textline ""
  bitfld.word 0 10. "    CTSN_EN       ,"," CTSN flow control disabled, CTSN flow control enabled "
  textline ""
  bitfld.word 0  9. "    RTSN_EN       ,"," RTSN flow control disabled, RTSN flow control enabled "
  textline ""
  bitfld.word 0  8. "    OD_EN         ,"," transmit line is regular output, transmit line is open drained "
  textline ""
  bitfld.word 0  7. "    SW_RST        ,"," flush RX and TX state and FIFO logic "
  textline ""
  bitfld.word 0  6. "    PAR_EN        ,"," no parity enabled, parity selected "
  textline ""
  bitfld.word 0  5. "    PAR_OD_EVEN   ,"," parity is even, parity is odd "
  textline ""
  bitfld.word 0  4. "    STOP_CFG      ,"," one stop bit selected, two stop bits selected "
  textline ""
  bitfld.word 0  2.--3. "    DATA_LENGTH   ,"," 8 bits, 7 bits, 9 bits, 8 bits "
group 0x008--0x009
 line.word 0 "INT_DIV, Integer Divider register"
  textline ""
  hexmask.word 0  0.--15.  1 "    INT_RATE       ,"
group 0x00C--0x00D
 line.word 0 "FRAC_DIV, Fractional Divider register"
  textline ""
  hexmask.word 0  0.--3.  1 "    INT_RATE       ,"
group 0x010--0x011
line.byte 0 "TX_FIFO_WM, TX FIFO Watermark register"
group 0x014--0x015
 line.byte 0 "RX_FIFO_WM, RX FIFO Watermark register"
rgroup 0x018--0x019
 line.word 0 "FIFO_INTSTAT, Interrupt Status register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
group 0x01C--0x01D
 line.word 0 "FIFO_INTEN, Interrupt Enable register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
wgroup 0x020--0x021
 hide.word 0 "FIFO_INT_CLR, Interrupt Clear register"
rgroup 0x024--0x025
 line.byte 0 "TX_FIFO_LVL, TX FIFO Level register"
rgroup 0x028--0x029
 line.byte 0 "RX_FIFO_LVL, RX FIFO Level register"
wgroup 0x02C--0x02D
 hide.word 0 "TX_DAT, TX Data register"
rgroup 0x030--0x031
 hide.word 0 "RX_DAT, RX Data register"
  in
rgroup 0x034--0x035
 line.word 0 "STAT, Status register"
  textline ""
  bitfld.word 0 9. "    RX_FULL  ,"," 0, 1 "
  bitfld.word 0 8. "    RX_EMPTY  ,"," 0, 1 "
  bitfld.word 0 3. "    CTS  ,"," 0, 1 "
  bitfld.word 0 2. "    RTS  ,"," 0, 1 "
  bitfld.word 0 1. "    TX_FULL  ,"," 0, 1 "
  bitfld.word 0 0. "    RX_FULL  ,"," 0, 1 "
tree.end

;-----------------------------------------------------
tree "UART3"
;-----------------------------------------------------
base a:0x05c00000
group 0x000--0x001
 line.word 0 "CTL, Control register"
  textline ""
  bitfld.word 0  0. "    UART_EN       ,"," 0, 1 "
group 0x004--0x005
 line.word 0 "CFG, Configuration register"
  textline ""
  bitfld.word 0 15. "    IRDA_UART     ,"," UART data format, IRDA data format "
  textline ""
  bitfld.word 0 14. "    IRDA_DRX_INV  ,"," data in not inverted, data in inverted "
  textline ""
  bitfld.word 0 13. "    IRDA_DTX_INV  ,"," data out not inverted, data in inverted "
  textline ""
  bitfld.word 0 11. "    BREAK_EN      ,"," break detection logic disabled, break detection logic enabled "
  textline ""
  bitfld.word 0 10. "    CTSN_EN       ,"," CTSN flow control disabled, CTSN flow control enabled "
  textline ""
  bitfld.word 0  9. "    RTSN_EN       ,"," RTSN flow control disabled, RTSN flow control enabled "
  textline ""
  bitfld.word 0  8. "    OD_EN         ,"," transmit line is regular output, transmit line is open drained "
  textline ""
  bitfld.word 0  7. "    SW_RST        ,"," flush RX and TX state and FIFO logic "
  textline ""
  bitfld.word 0  6. "    PAR_EN        ,"," no parity enabled, parity selected "
  textline ""
  bitfld.word 0  5. "    PAR_OD_EVEN   ,"," parity is even, parity is odd "
  textline ""
  bitfld.word 0  4. "    STOP_CFG      ,"," one stop bit selected, two stop bits selected "
  textline ""
  bitfld.word 0  2.--3. "    DATA_LENGTH   ,"," 8 bits, 7 bits, 9 bits, 8 bits "
group 0x008--0x009
 line.word 0 "INT_DIV, Integer Divider register"
  textline ""
  hexmask.word 0  0.--15.  1 "    INT_RATE       ,"
group 0x00C--0x00D
 line.word 0 "FRAC_DIV, Fractional Divider register"
  textline ""
  hexmask.word 0  0.--3.  1 "    INT_RATE       ,"
group 0x010--0x011
line.byte 0 "TX_FIFO_WM, TX FIFO Watermark register"
group 0x014--0x015
 line.byte 0 "RX_FIFO_WM, RX FIFO Watermark register"
rgroup 0x018--0x019
 line.word 0 "FIFO_INTSTAT, Interrupt Status register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
group 0x01C--0x01D
 line.word 0 "FIFO_INTEN, Interrupt Enable register"
  textline ""
  bitfld.word 0 12. "    RX_BREAK_ISR    ,"," 0, 1 "
  bitfld.word 0 11. "    RX_TIMEOUT_ISR   ,"," 0, 1 "
  textline ""
  bitfld.word 0 10. "    RX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  9. "    RX_FIFO_OVER_ISR ,"," 0, 1 "
  bitfld.word 0  8. "    RX_FIFO_UNDER_ISR ,"," 0, 1 "
  textline ""
  bitfld.word 0  1. "    TX_FIFO_WTR_ISR ,"," 0, 1 "
  bitfld.word 0  0. "    TX_FIFO_OVER_ISR ,"," 0, 1 "
wgroup 0x020--0x021
 hide.word 0 "FIFO_INT_CLR, Interrupt Clear register"
rgroup 0x024--0x025
 line.byte 0 "TX_FIFO_LVL, TX FIFO Level register"
rgroup 0x028--0x029
 line.byte 0 "RX_FIFO_LVL, RX FIFO Level register"
wgroup 0x02C--0x02D
 hide.word 0 "TX_DAT, TX Data register"
rgroup 0x030--0x031
 hide.word 0 "RX_DAT, RX Data register"
  in
rgroup 0x034--0x035
 line.word 0 "STAT, Status register"
  textline ""
  bitfld.word 0 9. "    RX_FULL  ,"," 0, 1 "
  bitfld.word 0 8. "    RX_EMPTY  ,"," 0, 1 "
  bitfld.word 0 3. "    CTS  ,"," 0, 1 "
  bitfld.word 0 2. "    RTS  ,"," 0, 1 "
  bitfld.word 0 1. "    TX_FULL  ,"," 0, 1 "
  bitfld.word 0 0. "    RX_FULL  ,"," 0, 1 "
tree.end
tree.end

;=====================================================
tree "TDM      - Time Division Multiplex"
;=====================================================
;-----------------------------------------------------
tree "TDM1"
;-----------------------------------------------------
base a:0x05f00000
group 0x000--0x001
 line.word 0 "TDM_ENABLE"
  bitfld.word 0 0. " TDM_EN ," " 0, 1 "
group 0x004--0x005
 line.word 0 "TDM_CONFIG_1"
  textline ""
  hexmask.word 0  0.--4. 1 "    TIME_SLOTS  ,"
  textline ""
  bitfld.word 0  8. "    TX_EDGE    ," " transmitted data is launched at the rising edge of SCLK, transmitted data is launched at the falling edge of SCLK "
  textline ""
  bitfld.word 0  9. "    RX_EDGE    ," " received data is sampled at the rising edge of SCLK, received data is sampled at the falling edge of SCLK "
  textline ""
  bitfld.word 0 10. "    SYNC_EDGE  ," " FSYNC signal is generated from SCLK rising edge, FSYNC signal is generated from SCLK falling edge "
  textline ""
  bitfld.word 0 11. "    FSYNC_MSTR_SLV ," " external,fsync "
  textline ""
  bitfld.word 0 12. "    CLK_MSTR_SLV   ," " external,serial clock "
  textline ""
  bitfld.word 0 13. "    AUTO_SYNC ," " no resync,rsync "
group 0x008--0x009
 line.word 0 "TDM_CONFIG_2"
  textline ""
  bitfld.word 0 0.--2. "    BANK_SIZE  ," " 2 FIFO lines/ 64 banks, 4 FIFO lines / 32 banks, 8 FIFO lines / 16 banks, 16 FIFO lines / 8 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks "
  textline ""
  bitfld.word 0 8. "    TRUNCATE   ," " only the upper N bits (N = the value in DATA_WIDTH field) are transmitted/contain the received bit stream, only the lower N bits are transmitted/contain the received bit stream "
  textline ""
  bitfld.word 0 9. "    SHIFT      ," " serial data is shifted LSB first, the serial data is shifted MSB first "
group 0x00C--0x00D
 line.word 0 "TDM_CYCLE"
  textline ""
  bitfld.word 0 0.--1. "    BIT_CYCLE (the number of SCLK cycles per bit equals BIT_CYCLE+1)                    ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 4.--5. "    TX_CYCLE (the SCLK cycle that launches the transmitted data is TX_CYCLE+1)          ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 8.--9. "    RX_CYCLE (the SCLK cycle that the received data is sampled at equals to RX_CYCLE+1) ," " 0, 1, 2, 3 "
group 0x010--0x011
 line.word 0 "TDM_FSYNC"
  textline ""
  hexmask.word 0 0.--4. 1 "    FSYNC_TIME_SLOT ,"
  textline ""
  hexmask.word 0 8.--12. 1 "    FSYNC_BIT       ,"
group 0x014--0x015
 line.word 0 "TDM_FSYNC_DUR"
  textline ""
  hexmask.word 0 0.--9. 1 "    FSYNC_DUR (the duration (in SCLK cycles) of the FSYNC signal highlevel in master mode is set to FSYNC_DUR+1)"
group 0x018--0x019
 line.word 0 "TDM_FIFO_WM"
  textline ""
  hexmask.word 0 0.--5.  1 "    TX_LVL "
  textline ""
  hexmask.word 0 8.--13. 1 "    RX_LVL "
wgroup 0x01C--0x01D
 hide.word 0 "FIFO_BNK_CNTL"
  textline ""
  bitfld.word 0 0. "    TX_FIFO_BNK_INC ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_FIFO_BNK_INC ," " 0, 1 "
group 0x020--0x021
 line.word 0 "TDM_INT_EN"
  textline ""
  bitfld.word 0 0. "    TX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 1. "    TX_EMPTY_INT_EN ," " disabled, enabled "
  textline ""
  bitfld.word 0 2. "    RX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 3. "    RX_FULL_INT_EN  ," " disabled, enabled "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT_EN    ," " disabled, enabled "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT_EN ," " disabled, enabled "
group 0x024--0x025
 line.word 0 "TDM_TF_INT_MSK"
wgroup 0x028--0x029
 hide.word 0 "TDM_INT_CLR"
  textline ""
  bitfld.word 0 0. "    TX_UNDRN_INT_CLR ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_OVRN_INT_CLR  ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    FSYNC_INT_CLR    ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    TX_FLAGS_INT_CLR ," " 0, 1 "
rgroup 0x02C--0x02D
 line.word 0 "TDM_INT_STATUS"
  textline ""
  bitfld.word 0 0. "    TX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    TX_UNDRN_INT ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    RX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    RX_OVRN_INT  ," " 0, 1 "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT    ," " 0, 1 "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT ," " 0, 1 "
group 0x030--0x031
 line.word 0 "TDM_STATUS"
  textline ""
  hexmask.word 0 0.--6.  1 "    TX_EMPTY_BNKS ,"
  textline ""
  hexmask.word 0 8.--14. 1 "    RX_FULL_BNKS  ,"
rgroup 0x034--0x035
 line.word 0 "TDM_TX_FLAGS"
wgroup 0x038--0x039
 hide.word 0 "TDM_TX_FIFO"
rgroup 0x03C--0x03D
 line.word 0 "TDM_RX_FIFO"
;TDM Transmit Registers Array 0x05F0 0A00 through 0x05F0 0A3C
;TDM Receive Registers Array 0x05F0 1200 through 0x05F0 123C
;TDM Frame Descriptors Array 0x05F0 1800 through 0x05F0 187C
tree.end

;-----------------------------------------------------
tree "TDM2"
;-----------------------------------------------------
base a:0x06000000
group 0x000--0x001
 line.word 0 "TDM_ENABLE"
  bitfld.word 0 0. " TDM_EN ," " 0, 1 "
group 0x004--0x005
 line.word 0 "TDM_CONFIG_1"
  textline ""
  hexmask.word 0  0.--4. 1 "    TIME_SLOTS  ,"
  textline ""
  bitfld.word 0  8. "    TX_EDGE    ," " transmitted data is launched at the rising edge of SCLK, transmitted data is launched at the falling edge of SCLK "
  textline ""
  bitfld.word 0  9. "    RX_EDGE    ," " received data is sampled at the rising edge of SCLK, received data is sampled at the falling edge of SCLK "
  textline ""
  bitfld.word 0 10. "    SYNC_EDGE  ," " FSYNC signal is generated from SCLK rising edge, FSYNC signal is generated from SCLK falling edge "
  textline ""
  bitfld.word 0 11. "    FSYNC_MSTR_SLV ," " external,fsync "
  textline ""
  bitfld.word 0 12. "    CLK_MSTR_SLV   ," " external,serial clock "
  textline ""
  bitfld.word 0 13. "    AUTO_SYNC ," " no resync,rsync "
group 0x008--0x009
 line.word 0 "TDM_CONFIG_2"
  textline ""
  bitfld.word 0 0.--2. "    BANK_SIZE  ," " 2 FIFO lines/ 64 banks, 4 FIFO lines / 32 banks, 8 FIFO lines / 16 banks, 16 FIFO lines / 8 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks "
  textline ""
  bitfld.word 0 8. "    TRUNCATE   ," " only the upper N bits (N = the value in DATA_WIDTH field) are transmitted/contain the received bit stream, only the lower N bits are transmitted/contain the received bit stream "
  textline ""
  bitfld.word 0 9. "    SHIFT      ," " serial data is shifted LSB first, the serial data is shifted MSB first "
group 0x00C--0x00D
 line.word 0 "TDM_CYCLE"
  textline ""
  bitfld.word 0 0.--1. "    BIT_CYCLE (the number of SCLK cycles per bit equals BIT_CYCLE+1)                    ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 4.--5. "    TX_CYCLE (the SCLK cycle that launches the transmitted data is TX_CYCLE+1)          ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 8.--9. "    RX_CYCLE (the SCLK cycle that the received data is sampled at equals to RX_CYCLE+1) ," " 0, 1, 2, 3 "
group 0x010--0x011
 line.word 0 "TDM_FSYNC"
  textline ""
  hexmask.word 0 0.--4. 1 "    FSYNC_TIME_SLOT ,"
  textline ""
  hexmask.word 0 8.--12. 1 "    FSYNC_BIT       ,"
group 0x014--0x015
 line.word 0 "TDM_FSYNC_DUR"
  textline ""
  hexmask.word 0 0.--9. 1 "    FSYNC_DUR (the duration (in SCLK cycles) of the FSYNC signal highlevel in master mode is set to FSYNC_DUR+1)"
group 0x018--0x019
 line.word 0 "TDM_FIFO_WM"
  textline ""
  hexmask.word 0 0.--5.  1 "    TX_LVL "
  textline ""
  hexmask.word 0 8.--13. 1 "    RX_LVL "
wgroup 0x01C--0x01D
 hide.word 0 "FIFO_BNK_CNTL"
  textline ""
  bitfld.word 0 0. "    TX_FIFO_BNK_INC ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_FIFO_BNK_INC ," " 0, 1 "
group 0x020--0x021
 line.word 0 "TDM_INT_EN"
  textline ""
  bitfld.word 0 0. "    TX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 1. "    TX_EMPTY_INT_EN ," " disabled, enabled "
  textline ""
  bitfld.word 0 2. "    RX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 3. "    RX_FULL_INT_EN  ," " disabled, enabled "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT_EN    ," " disabled, enabled "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT_EN ," " disabled, enabled "
group 0x024--0x025
 line.word 0 "TDM_TF_INT_MSK"
wgroup 0x028--0x029
 hide.word 0 "TDM_INT_CLR"
  textline ""
  bitfld.word 0 0. "    TX_UNDRN_INT_CLR ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_OVRN_INT_CLR  ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    FSYNC_INT_CLR    ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    TX_FLAGS_INT_CLR ," " 0, 1 "
rgroup 0x02C--0x02D
 line.word 0 "TDM_INT_STATUS"
  textline ""
  bitfld.word 0 0. "    TX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    TX_UNDRN_INT ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    RX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    RX_OVRN_INT  ," " 0, 1 "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT    ," " 0, 1 "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT ," " 0, 1 "
group 0x030--0x031
 line.word 0 "TDM_STATUS"
  textline ""
  hexmask.word 0 0.--6.  1 "    TX_EMPTY_BNKS ,"
  textline ""
  hexmask.word 0 8.--14. 1 "    RX_FULL_BNKS  ,"
rgroup 0x034--0x035
 line.word 0 "TDM_TX_FLAGS"
wgroup 0x038--0x039
 hide.word 0 "TDM_TX_FIFO"
rgroup 0x03C--0x03D
 line.word 0 "TDM_RX_FIFO"
;TDM Transmit Registers Array 0x05F0 0A00 through 0x05F0 0A3C
;TDM Receive Registers Array 0x05F0 1200 through 0x05F0 123C
;TDM Frame Descriptors Array 0x05F0 1800 through 0x05F0 187C
tree.end

;-----------------------------------------------------
tree "TDM3"
;-----------------------------------------------------
base a:0x06100000
group 0x000--0x001
 line.word 0 "TDM_ENABLE"
  bitfld.word 0 0. " TDM_EN ," " 0, 1 "
group 0x004--0x005
 line.word 0 "TDM_CONFIG_1"
  textline ""
  hexmask.word 0  0.--4. 1 "    TIME_SLOTS  ,"
  textline ""
  bitfld.word 0  8. "    TX_EDGE    ," " transmitted data is launched at the rising edge of SCLK, transmitted data is launched at the falling edge of SCLK "
  textline ""
  bitfld.word 0  9. "    RX_EDGE    ," " received data is sampled at the rising edge of SCLK, received data is sampled at the falling edge of SCLK "
  textline ""
  bitfld.word 0 10. "    SYNC_EDGE  ," " FSYNC signal is generated from SCLK rising edge, FSYNC signal is generated from SCLK falling edge "
  textline ""
  bitfld.word 0 11. "    FSYNC_MSTR_SLV ," " external,fsync "
  textline ""
  bitfld.word 0 12. "    CLK_MSTR_SLV   ," " external,serial clock "
  textline ""
  bitfld.word 0 13. "    AUTO_SYNC ," " no resync,rsync "
group 0x008--0x009
 line.word 0 "TDM_CONFIG_2"
  textline ""
  bitfld.word 0 0.--2. "    BANK_SIZE  ," " 2 FIFO lines/ 64 banks, 4 FIFO lines / 32 banks, 8 FIFO lines / 16 banks, 16 FIFO lines / 8 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks, 32 FIFO lines / 4 banks "
  textline ""
  bitfld.word 0 8. "    TRUNCATE   ," " only the upper N bits (N = the value in DATA_WIDTH field) are transmitted/contain the received bit stream, only the lower N bits are transmitted/contain the received bit stream "
  textline ""
  bitfld.word 0 9. "    SHIFT      ," " serial data is shifted LSB first, the serial data is shifted MSB first "
group 0x00C--0x00D
 line.word 0 "TDM_CYCLE"
  textline ""
  bitfld.word 0 0.--1. "    BIT_CYCLE (the number of SCLK cycles per bit equals BIT_CYCLE+1)                    ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 4.--5. "    TX_CYCLE (the SCLK cycle that launches the transmitted data is TX_CYCLE+1)          ," " 0, 1, 2, 3 "
  textline ""
  bitfld.word 0 8.--9. "    RX_CYCLE (the SCLK cycle that the received data is sampled at equals to RX_CYCLE+1) ," " 0, 1, 2, 3 "
group 0x010--0x011
 line.word 0 "TDM_FSYNC"
  textline ""
  hexmask.word 0 0.--4. 1 "    FSYNC_TIME_SLOT ,"
  textline ""
  hexmask.word 0 8.--12. 1 "    FSYNC_BIT       ,"
group 0x014--0x015
 line.word 0 "TDM_FSYNC_DUR"
  textline ""
  hexmask.word 0 0.--9. 1 "    FSYNC_DUR (the duration (in SCLK cycles) of the FSYNC signal highlevel in master mode is set to FSYNC_DUR+1)"
group 0x018--0x019
 line.word 0 "TDM_FIFO_WM"
  textline ""
  hexmask.word 0 0.--5.  1 "    TX_LVL "
  textline ""
  hexmask.word 0 8.--13. 1 "    RX_LVL "
wgroup 0x01C--0x01D
 hide.word 0 "FIFO_BNK_CNTL"
  textline ""
  bitfld.word 0 0. "    TX_FIFO_BNK_INC ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_FIFO_BNK_INC ," " 0, 1 "
group 0x020--0x021
 line.word 0 "TDM_INT_EN"
  textline ""
  bitfld.word 0 0. "    TX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 1. "    TX_EMPTY_INT_EN ," " disabled, enabled "
  textline ""
  bitfld.word 0 2. "    RX_INT_EN       ," " disabled, enabled "
  textline ""
  bitfld.word 0 3. "    RX_FULL_INT_EN  ," " disabled, enabled "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT_EN    ," " disabled, enabled "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT_EN ," " disabled, enabled "
group 0x024--0x025
 line.word 0 "TDM_TF_INT_MSK"
wgroup 0x028--0x029
 hide.word 0 "TDM_INT_CLR"
  textline ""
  bitfld.word 0 0. "    TX_UNDRN_INT_CLR ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    RX_OVRN_INT_CLR  ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    FSYNC_INT_CLR    ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    TX_FLAGS_INT_CLR ," " 0, 1 "
rgroup 0x02C--0x02D
 line.word 0 "TDM_INT_STATUS"
  textline ""
  bitfld.word 0 0. "    TX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 1. "    TX_UNDRN_INT ," " 0, 1 "
  textline ""
  bitfld.word 0 2. "    RX_INT       ," " 0, 1 "
  textline ""
  bitfld.word 0 3. "    RX_OVRN_INT  ," " 0, 1 "
  textline ""
  bitfld.word 0 4. "    FSYNC_INT    ," " 0, 1 "
  textline ""
  bitfld.word 0 5. "    TX_FLAGS_INT ," " 0, 1 "
group 0x030--0x031
 line.word 0 "TDM_STATUS"
  textline ""
  hexmask.word 0 0.--6.  1 "    TX_EMPTY_BNKS ,"
  textline ""
  hexmask.word 0 8.--14. 1 "    RX_FULL_BNKS  ,"
rgroup 0x034--0x035
 line.word 0 "TDM_TX_FLAGS"
wgroup 0x038--0x039
 hide.word 0 "TDM_TX_FIFO"
rgroup 0x03C--0x03D
 line.word 0 "TDM_RX_FIFO"
;TDM Transmit Registers Array 0x05F0 0A00 through 0x05F0 0A3C
;TDM Receive Registers Array 0x05F0 1200 through 0x05F0 123C
;TDM Frame Descriptors Array 0x05F0 1800 through 0x05F0 187C
tree.end
tree.end

;=====================================================
tree "BMP      - Burst Mode Processor"
;=====================================================
base a:0x08300000
group 0x00--0x03     "BCNT_GLOBAL"
 line.long 0 ""
  textline ""
  bitfld.long 0 11.  "          DPLL_SYMREC: Symbol recovery unit selection" "old, CT1+SPIF"
  textline ""
  bitfld.long 0 08.  "          RESERVED                                   " "0, 1"
  textline ""
  bitfld.long 0 07.  "          SEL_TBU2:sellects time base unit mode      " "inactive,active"
  textline ""
  bitfld.long 0 06.  "          AUTO_HW_DATA_FETCH                         " "inactive,activate"
  textline ""
  bitfld.long 0 3--5 "          BITCLOCK-SEL                               " "0.1152 MHz , 0.288 MHz , 0.384 MHz , 0.576 MHz , 1.152 MHz , reserved , reserved , reserved "
  textline ""
  bitfld.long 0 2    "          SEL_TBU                                    " "DECT , reserved"
  textline "" 
  bitfld.long 0 1    "          BLRES_BMP                                  " "run , reset BMP "
  textline ""
  bitfld.long 0 0    "          BMP_ON                                     " "off , on"

group 0x04--0x07 "BCNT_REF (DECT 11519=0x2CFF)"
  line.long 0 ""
  textline ""
  bitfld.long 0 28.--31. "          BCNT_REF1     "   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 12.--15. "          BCNT_REF0     "   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x08--0x0b "BCNT_S_REF"
  line.long 0 ""
  textline ""
  bitfld.long 0 28.--31. "          BCNT_S_REF1     "  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 12.--15. "          BCNT_S_REF0     "  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x0c--0x0f "BCNT_VAL"
  line.long 0 ""
  bitfld.long 0 12.--13. "BCNT_VAL "    "0,1,2,3"
  bitfld.long 0 08.--11. " "            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
 
group 0x10--0x13 "BMP_REF"
  line.long 0 ""
  bitfld.long 0 28.--31. "BMP_REF "     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x014--0x017 "CNT_MOD (BCNT_S_MOD (1E0) BCNT_MOD (2D00))"
  line.long 0 ""
  textline ""
  bitfld.long 0 24.--27. "          BCNT_S_MOD   "       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. ""                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. ""                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 12.--13. "          BCNT_MOD     "       "0,1,2,3"
  bitfld.long 0 08.--11. ""                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. ""                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. ""                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x018--0x01b "COM_AD0"
 line.long 0 ""
  textline ""
  bitfld.long 0 24. 	 "          M_COM_END: end address offset           "   "0,1"
  bitfld.long 0 12.--15. ""                                                     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. ""            				                "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 16. 	 "          M_COM_STA:start address offset b16      "   "0,1"
  bitfld.long 0 04.--07. ""                                                     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. ""                                                     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x01c--0x01f "COM_AD1"
 line.long 0 ""
  textline ""
  bitfld.long 0 24. 	 "          RF_COM_END:end address offset b16       "   "0,1"
  bitfld.long 0 12.--15. ""                                                     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. ""            				                "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 16. 	 "          RF_COM_STA:start address offset b16     "   "0,1"
  bitfld.long 0 04.--07. ""                                                     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. ""            	                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""

group 0x020--0x023 "COM_AD2"
 line.long 0 ""
  textline ""
  bitfld.long 0 24. 	 "          I_COM_END:end address offset b16       "    "0,1"
  bitfld.long 0 12.--15. ""                                                     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. ""            				                "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 16. 	 "          I_COM_STA:start address offset b16     "    "0,1"
  bitfld.long 0 04.--07. ""                                                     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. ""            	                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""

group 0x024--0x027 "COM_AD3"
 line.long 0 ""
  textline ""
  bitfld.long 0 24. 	 "          R_COM_END:end address offset b16       "    "0,1"
  bitfld.long 0 12.--15. ""                                                     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. ""            				                "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 16. 	 "          R_COM_STA:start address offset b16     "    "0,1"
  bitfld.long 0 04.--07. ""                                                     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. ""            			                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""

group 0x028--0x02b "CP_X_TIME"
 line.long 0 ""
  textline ""
  bitfld.long 0 3 "          FORCE_M_EV   " "no force,force"
  textline ""
  bitfld.long 0 2 "          FORCE_RF_EV  " "no force,force"
  textline ""
  bitfld.long 0 1 "          FORCE_R_EV   " "no force,force"
  textline ""
  bitfld.long 0 0 "          FORCE_T_EV   " "no force,force"
  textline ""

group 0x02c--0x02f "CRC_CON0"
 line.long 0 ""
  textline ""
  bitfld.long 0 17. 	 "          CRC_LEN0                             " "CRC=8 bits,CRC=16 bits"
  textline ""
  bitfld.long 0 16. 	 "          CRC_POL0: set the CRC polynomial     " "0,1"
  bitfld.long 0 12.--15. " "                                               "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "            			           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                               "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "            			           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
   
group 0x030--0x033 "CRC_CON1"
 line.long 0 ""
  textline ""
  bitfld.long 0 17. 	 "          CRC_LEN1                             " "CRC=8 bits,CRC=16 bits"
  textline ""
  bitfld.long 0 16. 	 "          CRC_POL1: set the CRC polynomial     " "0,1"
  bitfld.long 0 12.--15. " "                                               "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "            			           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                               "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "            			           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x034--0x037 "CRC_CON2"
 line.long 0 ""
  textline ""
  bitfld.long 0 17. 	 "          DIS_INV: disable the last bit invert for CRC " "invert,invert disabled"
  textline ""
  bitfld.long 0 12.--15. "          PRE_CRC: preload the CRC                     " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "            			                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "            		                           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x10C--0x10F "CRC_CON3"
 line.long 0 ""

group 0x110--0x113 "CRC_CON4"
 line.long 0 ""
 textline ""
 bitfld.long 0 03.     " ones complement of calculated CRC-32 "    "ones complement is calculated, disabled" 
 bitfld.long 0 01.--2. " CRC_LEN2[1:0]"    "8, 16, 32, reserved "
 bitfld.long 0 00.     " MSB of 33bit polynomial CRC register "    "0, 1"
 
group 0x114--0x117 "CRC_CON5"
 line.long 0 ""    

group 0x038--0x03b "ENC_DAT0"
 line.long 0 ""
  bitfld.long 0 28.--31. "IV0: init vector  "     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x03c--0x03f "ENC_DAT1"
 line.long 0 ""
  bitfld.long 0 28.--31. "IV1: init vector  "     "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x040--0x043 "ENC_DAT2"
 line.long 0 ""
  bitfld.long 0 28.--31. "CK0: Encryption Key "   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x044--0x047 "ENC_DAT3"
 line.long 0 ""
  bitfld.long 0 28.--31. "CK1: Encryption Key "   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x048--0x04b "ENC_DAT4"
 line.long 0 ""
  textline ""
  bitfld.long 0 13.      "          CT_DECODE: init vector        " "0,1"
  textline ""
  bitfld.long 0 12.      "          ENCR_EN: encryption eneable   " "disabled,enabled on next rising edge"
  textline ""
  bitfld.long 0 11.      "          PRECLOCK                      " "not preclocked,preclocked"
  textline ""
  bitfld.long 0 08.--10. "          SEQ_LEN                       " "0,1,2,3,4,5,6,7"
  bitfld.long 0 04.--07. " "                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x04c--0x04f "ENC_DAT5"
 line.long 0 ""
  ;bitfld.long 0 12.--15. "BD_ADDR_SIP: BT device master addr " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. "RESERVED                           " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x050--0x053 "ENC_DAT6"
 line.long 0 ""
  textline ""
  ;bitfld.long 0 26.--29. "          CIP_L: effective length      " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  ;bitfld.long 0 24.--25. "          BD_TP_CIP: RT Frame couner   " "0,1,2,3"
  bitfld.long 0 20.--23. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x054--0x057 "FCNT_MOD"
 line.long 0 ""
  bitfld.long 0 28.--31. "FCNT_MOD: modulo of frame counter "   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x058--0x05b "FCNT_VAL"
 line.long 0 ""
  bitfld.long 0 28.--31. "FCNT_VAL: current frame counter value "  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

;group 0x05c--0x05f "FHU_CON0"
; line.long 0 ""
;  bitfld.long 0 24.--27. "BD_ADDR_FHU: part of the RT frame counter " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
 ; bitfld.long 0 20.--23. " "                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  ;bitfld.long 0 16.--19. " "                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 12.--15. " "                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 08.--11. " "                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 04.--07. " "                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 00.--03. " "                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

;group 0x060--0x063 "FHU_CON1"
; line.long 0 ""
;  bitfld.long 0 24.--27. "BD_TB_FHU: part of the RT frame counter " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 20.--23. " "                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 16.--19. " "                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 12.--15. " "                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 08.--11. " "                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 04.--07. " "                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 00.--03. " "                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

;group 0x064--0x067 "FHU_CON2"
; line.long 0 ""
;  textline ""
;  bitfld.long 0 7.       "          SCAN_STATE: set BT page or inquiry-scan state " "0,1"
;  textline ""
;  bitfld.long 0 6.       "          CON_STATE: set BT connection state            " "0,1"
;  textline ""
;  bitfld.long 0 5.       "          HOP_79_23: modulo                             " "23,79"
;  textline ""
;  bitfld.long 0 04.      "          DATA_IN: for freq hop calculation             " "0,1"
;  bitfld.long 0 00.--03. " "                                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

;group 0x068--0x06b "FHU_STAT"
; line.long 0 ""
;  textline ""
;  bitfld.long 0 12.      "          PERM5: from freq hop seq calculation    " "0,1"
;  bitfld.long 0 08.--11. " "                                                  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  textline ""
;  bitfld.long 0 04.--07. "          DATA_OUT: from freq hop seq calculation " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
;  bitfld.long 0 00.--03. " "                                                  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x06c--0x06f "M_POINTER"
 line.long 0 ""
  bitfld.long 0 04.--07. "M_POINTER: current value of M point in MCU "    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x070--0x073 "MAX_ERROR"
 line.long 0 ""
  bitfld.long 0 16. "MAX_ERROR: measured phase error "    "0,1"
  bitfld.long 0 12.--15. " "                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x074--0x077 "PHASE_CON"
 line.long 0 ""
  textline ""
  bitfld.long 0 3.--4.  "          CORR_SPEED: set phase adj speed      " "2x72ns,4x72ns,8x72ns,72ns per 868ns"
  textline ""
  bitfld.long 0 1.--2.  "          SYNC_SOURCE_SEL: set synch source    " "none,RCU,IOM,SYNCPORT"
  textline ""
  bitfld.long 0 0.      "          MEAS_ONLY: phase measurement control " "with phase correction,without phase correction"


group 078--07B "PHASE_ERROR"
 line.long 0 ""
  textline ""
  bitfld.long  0 19.      "           PHASE_CORR_IN_PROG: status of phase err measurment.        " "done, in progress"
  textline ""
  bitfld.long  0 18.      "           MAX PHASE_ERROR_EXC: maximum phase error exceeded.         " "not exceeded , exceeded "
  textline ""
  bitfld.long  0 17.      "           PHASE_ERROR_S: Sign of phase error between int-ext timing. " "Positive , Negative "
  textline ""
  bitfld.long  0 16.      "           PHASE_ERROR: Absolute value of phase error.                " "0,1"
  bitfld.long  0 12.--15. " "                                                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long  0 08.--11. " "                                                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long  0 04.--07. " "                                                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long  0 00.--03. " "                                                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x07c--0x07f "PHASE_OFFSET"
 line.long 0 ""
  textline ""
  bitfld.long 0 17.       "          PHASE_OFFSET_S: sign of phase error offset  " "0,1"
  textline ""
  bitfld.long 0 16.       "          PHASE_OFFSET: abs val of phase error offset " "0,1"
  bitfld.long 0 012.--15. " "                                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11.  " "                                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07.  " "                                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03.  " "                                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x080--0x083 "RBUF_CON"
 line.long 0 ""
  textline ""
  bitfld.long 0 08.      "          CP_R_BUF_LEN " "0,1"
  textline ""
  bitfld.long 0 04.--07. "          R_BUF_LEN    " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. ""                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x084--0x087 "R_BUF0 (read only)"
 line.long 0 ""
  bitfld.long 0 28.--31. "R_BUF0, MSB first "                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x088--0x08B "R_BUF1 (read only)"
 line.long 0 ""
  bitfld.long 0 28.--31. "R_BUF1, MSB first "                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x08c--0x08f "R_POINTER "
 line.long 0 ""
  bitfld.long 0 04.--07. "R_POINTER: curr cal of pointer in RCU " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"


group 0x090--0x093 "RF_POINTER "
 line.long 0 ""
  bitfld.long 0 04.--07. "RF_POINTER: curr cal of pointer in MCU " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x094--0x097 "RFPU_CON"
 line.long 0 ""
  textline ""
; bitfld.long 0 0x10      "          REF_CLK_SEL     " "controlled by slice_ctrl & en_ref_clk , controlled by en_ref_clk "
  bitfld.long 0 16.       "          REF_CLK_SEL     " "controlled by en_ref_clk ,controlled by slice_ctrl & en_ref_clk "
  textline ""
  bitfld.long 0 15.       "          FAD_SWAP        " "default , swapped "
  textline ""
  bitfld.long 0 14.       "          IF_SLC_CTRL_DIS " "not disabled , disabled "
  textline ""
  bitfld.long 0 12.--13.  "          SLC_CTRL_SEL    " "rf_sig_rfcu , scl_ctrl , rcu_sig , slc_ctrl_eop "
  textline ""
  bitfld.long 0 9.--11.   "          RF_SIG_NUM      " "res , res , RFSIG[2] , RFSIG[3] , RFSIG[4] , RFSIG[5] , RFSIG[6] , RFSIG[7] "
  textline ""
  bitfld.long 0 8.        "          FAD_INV         " "set by MCU , inverted "
  textline ""
  bitfld.long 0 0.--7.    "          RF_SIG_CON      " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 0.--7.    " "                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x098--0x09b "RPU_CON0"
 line.long 0 ""
  textline ""
  bitfld.long 0 30.--31.  "          THR_SYNC_H: sets number of additional errors req'd to gen sync_OK " "0,4,8,12 "
  textline ""
  bitfld.long 0 29.       "          RDATA_RFSIG2_SEL: set traditional or enhanced RF mode             " "traditional, enhanced"
  textline ""
  bitfld.long 0 28.       "          SEL_R_FILTER: set filter method                                   " "signel spike, majority voting"
  textline ""
  bitfld.long 0 27.       "          RDATA_INV                                                         " "not inverted , inverted "
  textline ""
  bitfld.long 0 23.--26.  "          ID_LEN: lenght of ID pattern                                      " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 21.--22.  "          ID_COUNT. max value of ID counter                                 " "0,1,2,3"
  bitfld.long 0 17.--20.  " "                                                                            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 13.--16.  " "                                                                            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 11.--12.  "          THR_ID_L: sets number of errors req'd to gen ID_OK                " "0,1,2,3 "
  textline ""
  bitfld.long 0 10.       "          COND_SEL                                                          " "find sync_ok , find sync_ok AND id_ok "
  textline ""
  bitfld.long 0 8.--9.    "          THR_SYNC                                                          " "no errors , 1 error , 2 errors , 3 errors "
  textline ""
  bitfld.long 0 6.--7.    "          SYNC_LEN: syncword length                                         " "0,1,2,3 "
  bitfld.long 0 2.--5.    " "                                                                            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 1.        "          FREEZE_CONST                                                      " "infinite , 8 "
  textline ""
  bitfld.long 0 0.        "          R_DATA_SOURCE: sel which data source to use                       " "source=r data(RF sig2),source=demodulator"

group 0x09c--0x09f "RPU_CON1"
 line.long 0 ""
  textline ""
  bitfld.long 0 29.         "          SEL_R_RATE: set EDR rate (in combo with RRATE0  " "triple or half (see RRATE0), double"
  textline ""
  bitfld.long 0 28.         "          SEL_DUTY_DET                                    " "disabled , enabled "
  textline ""
  bitfld.long 0 27.         "          SEL_RFILTER2                                    " "majority , triangular "
  textline ""
  bitfld.long 0 26.         "          FREEZE_CONST2                                   " "8 , 16 "
  textline ""
  bitfld.long 0 25.         "          SEL_R_RATE0: set EDR rate (in combo with RRATE1 " "triple, double or half"
  textline ""
  bitfld.long 0 23.--24.    "          THR_ID_H                                        " "+0 errors, +4 errors , +8 errors , +12 errors "
  textline ""
  bitfld.long 0 22.         "          EOP_RPLL_SYNC                                   " "not latched by clk_r , latched by clk_r "
  textline ""
  hexmask.long 0 15.--21. 1 "          EOP_REEN_DLY                                    "   
  textline ""
  hexmask.byte 1 11.--14. 1 "          EOP_START_DLY                                   "   
  textline ""
  bitfld.long 0 10.         "          CP_R_BUF                                        " "- , Copy RBUF "
  textline ""
  bitfld.long 0 9.          "          RDIR                                            " "last received is LSB , first received is LSB "
  textline ""
  bitfld.long 0 6.--8.      "          PRE_R_SCR: recieve scrambler reset value        " "0,1,2,3,4,5,6,7"
  bitfld.long 0 2.--5.      " "                                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 1.          "          SEL_R_SCR                                       " "5-bit , 7-bit "
  textline ""
  bitfld.long 0 0.          "          RES_R_XCRC: auto reset the XCRC block           " "0, 1"

group 0x0a0--0x0a3 "RPU_PAT"
 line.long 0 ""
  textline ""
  bitfld.long 0 26.      "          EOP_S_SEL                                " "0,1"
  bitfld.long 0 22.--25. " "                                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 20.--21. "          EOP_PAT                                  " "0,1,2,3"
  bitfld.long 0 16.--19. " "                                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 12.--15. "          ID_PAT: bitpattern used for ID detection " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 8.--11.  " "                                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 4.--7.   " "                                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 0.--3.   " "                                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0a4--0x0a7 "RPU_STAT0 "
 line.long 0 ""
  textline ""
  bitfld.long 0 10.       "          EOP_STAT                                      " "EOP not found , EOP found "
  textline ""
  bitfld.long 0 9.        "          ID_STAT                                       " "ID not found , ID found "
  textline ""
  bitfld.long 0 8.        "          SYNC_STAT                                     " "SYNC not found , SYNC found "
  textline ""
  bitfld.long 0 4.--7.    "          PREAM_DUMP: read last 8 bits before sync word " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 0.--3.    " "                                                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0a8--0x0ab "RPU_STAT1 (read only)"
 line.long 0 ""
  textline ""
  bitfld.long 0 28.--31. "          CRC_DUMP: read 16bit CRC shift reg                " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                                            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                                            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                                            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 12.--15. "          FEC_ERR: read number of 15bit uncorrectale blocks " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                                            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 00.--03. "          XRC_DUMP: read 4bit XCRC shift reg                " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x118--0x11b "RPU_STAT2 (read only)"
 line.long 0 ""
  textline ""
  bitfld.long 0 0.--31.  "          CRC_DUMP: read 32bit CRC shift reg                " " "    
  
group 0x0ac--0x0af "SCNT_MOD"
 line.long 0 ""
  textline ""
  bitfld.long 0 12.--15. "          SCNT_MOD1 "               "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 04.--07. "          SCNT_MOD0 "               "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0b0--0x0b3 "SCNT_VAL"
 line.long 0 ""
  textline ""
  bitfld.long 0 12.--15. "          SCNT_VAL1   "             "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 04.--07. "          SCNT_VAL0 "               "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0b4--0x0b7 "R_BUF0"
 line.long 0 ""
  bitfld.long 0 28.--31. "SIF_BUF0 "                            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0b8--0x0bb "R_BUF1"
 line.long 0 ""
  bitfld.long 0 28.--31. "SIF_BUF1 "                            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0bc--0x0bf "R_BUF2"
 line.long 0 ""
  bitfld.long 0 28.--31. "SIF_BUF2 "                            "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0c0--0x0c3 "SIF_CON"
 line.long 0 ""
  textline ""
  bitfld.long 0 14.      "          SIF_MUX_EN              " "0,1"
  textline ""
  bitfld.long 0 13.      "          SIF_CLK_DEL             " "0,1"
  textline ""
  bitfld.long 0 12.      "          SIF_OFF_MODE            " "0,1"
  textline ""
  bitfld.long 0 11.      "          SIF_DIR                 " "0,1"
  textline ""
  bitfld.long 0 10.      "          SIF_OFF_POL             " "0,1"
  textline ""
  bitfld.long 0 9.       "          SIF_CLK_POL             " "0,1"
  textline ""
  bitfld.long 0 7.--8.   "          SIF_SPEED               " "0,1,2,3"
  textline ""
  bitfld.long 0 04.--06. "          SIF_LENGTH              " "0,1,2,3,4,5,6,7"
  bitfld.long 0 00.--03. " "                                  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0c4--0x0c7 "START_TIME (read only)"
 line.long 0 ""
  bitfld.long 0 12.--13. "START_TIME "                          "0,1,2,3"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0c8--0x0cb "SYNC_PAT0"
 line.long 0 ""
  bitfld.long 0 28.--31. "SYNC_PAT0 "                           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0cc--0x0cf "SYNC_PAT1"
 line.long 0 ""
  bitfld.long 0 28.--31. "SYNC_PAT1 "                           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0c8--0x0cb "SYMREC_CON0"
 line.long 0 ""    
  bitfld.long 0 31.      " PHASE_LOAD   "                       "0,loaded"
  bitfld.long 0 27.--30. " PHASE_ABS    "                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 25.      " FREQ_10M_13M "                       "13.824,10.368"
  bitfld.long 0 20.--24. " STHD         "                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 18.--19. " CORR_PH      "                       "-1,-2,0,+1"
  bitfld.long 0 00.--15. " Syncword     "                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0cc--0x0cf "SYMREC_CON1"
 line.long 0 ""
  bitfld.long 0 15.--18. " DELAY_IN_BITS "                        "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F "
  bitfld.long 0 14.      " DECT_MHS "                             "EDCT,DECT "
  bitfld.long 0 10.      " PP_FP "                                "FP,PP "
  bitfld.long 0 9.       " RX_DATA_INV "                          "normal,inverted "
  bitfld.long 0 8.       " S_INV_DIS "                            "inverted, normal "
  bitfld.long 0 00.--7.  " CTHD "                                 "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F "
        
group 0x0d0--0x0d3 "SYPO_CON"
 line.long 0 ""
  bitfld.long 0 0. "SYPO_MASTER_SEL: set syncport master mode" "slave,master"

group 0x0d4--0x0d7 "SYPO_REF_CNT"
 line.long 0 ""
  textline ""
  bitfld.long 0 18.--19. "          PULSE_LEN: pulse length of wide pulses "   "2.3ms, 3.4ms, 4.5ms, res"
  textline ""
  bitfld.long 0 16.--17. "          SYPO_REF_CNT: syncport reference value "   "0,1,2,3"
  bitfld.long 0 12.--15. " "                                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                                   "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x0d8--0x0db "T_BUF_LEN"
 line.long 0 ""
  bitfld.long 0 04.--07. "T_BUF_LEN: number of bits transmitted = this reg to 0 " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0dc--0x0df "T_BUF0"
 line.long 0 ""
  bitfld.long 0 28.--31. "T_BUF0 "                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  
group 0x0e0--0x0e3 "T_BUF1"
 line.long 0 ""
  bitfld.long 0 28.--31. "T_BUF1 "                              "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 24.--27. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 20.--23. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                    "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0e4--0x0e7 "T_POINTER"
 line.long 0 ""
  bitfld.long 0 04.--07. "T_POINTER: current value of t point in TCU " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                           "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

group 0x0e8--0x0eb "TPU_CON"
 line.long 0 ""
  textline ""
  bitfld.long 0 13.--14.    "          SEL_T_RATE 2bits                               " "standard,EDR double,EDR triple,half"
  textline ""
  bitfld.long 0 12.         "          TDATA_INACTIVE_VALUE: when TCU is inactive     " "TDATA=all 0, TDATA=all 1"
  textline ""
  bitfld.long 0 11.         "          TDATA_INV                                      " "not inverted , inverted"
  textline ""
  bitfld.long 0 10.         "          RES_T_XCRC                                     " "default , reset T_XCRC"
  textline ""
  bitfld.long 0 9.          "          SEL_T_SCR                                      " "5-bit , 7-bit"
  textline ""
  bitfld.long 0 6.--8.      "          PRE_T_SCR: tx scambler preset value            " "0,1,2,3,4,5,6,7"
  bitfld.long 0 2.--5.      " "                                                         "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 1.          "          T_DIR                                          " "last sent is LSB , first sent is LSB "
  textline ""
  bitfld.long 0 0.          "          CP_T_BUF: copy TBUF0/1 to TBUF then auto reset " "do not copy,copy"

group 0x0ec--0x0ef "COM_ADD_RDATA"
 line.long 0 ""
  textline ""
  bitfld.long 0 24.        "          R_DATA_COM_END: BMP RAM data cache end address  "  "0,1"
  bitfld.long 0 20.--23.   " "	                                                         "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19.   " "	                                                         "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 8.         "        R_DATA_COM_STA: BMP RAM data cache start address  "  "0,1"
  bitfld.long 0 4.--7.     " "          	                                         "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 0.--3.     " "	                                                         "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""

group 0x0f0--0x0f3 "COM_ADD_TDATA"
 line.long 0 ""
  textline ""
  bitfld.long 0 24.        "          T_DATA_COM_END: BMP RAM data cache end address "    "0,1"
  bitfld.long 0 20.--23.   " "	                                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19.   " "	                                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 8.         "          T_DATA_COM_STA: BMP RAM data cache start address "  "0,1"
  bitfld.long 0 4.--7.     " "	                                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 0.--3.     " "	                                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""

group 0x0f4--0x0f7 "RDATA_POINTER"
 line.long 0 ""
  bitfld.long 0 8.         "RDATA_PTR: offset from rdata_sta "    "0,1"
  bitfld.long 0 4.--7.     " "	                                  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 0.--3.     " "	                                  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""

group 0x0f8--0x0fb "TDATA_POINTER"
 line.long 0 ""
  bitfld.long 0 8.         "TDATA_PTR: offset from Tdata_sta "   "0,1"
  bitfld.long 0 4.--7.     " "	                                 "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 0.--3.     " "	                                 "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""

group 0x0fc--0x0ff "DEMOD_ISI"
line.long 0 ""
  textline ""
  bitfld.long  0 20.--23. "          ISI_RANGE: intersmbol interference range " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long  0 16.--19. " "	                                                "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
;  bitfld.long  0 15.     "          ISI_DISABLE: disable ISI calculation.    " "enable,disable"
;  textline ""
  bitfld.long  0 08.--10. "          ISI GAIN                                 " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long  0 04.--07. "          ISI_VALUE: output of ISI caluclator.     " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long  0 00.--03. " "	                                                "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""

group 0x100--0x103 "DEMOD_MODUL"
line.long 0 ""
  textline ""
  bitfld.long  0 20.--23. "          MODUL_RANGE: modulation index range.            " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long  0 16.--19. " "                                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
; bitfld.long  0 15.      "          MODUL_DISABLE. disable modulation calculation.  " "enable,disable"
; textline ""
  bitfld.long  0 08.--10. "          MODULE_GAIN: modulation index gain              " "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long  0 04.--07. "          MODUL_VALUE: output of modulation caluclator.   " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long  0 00.--03. " "                                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""

group 0x104--0x107 "DEMOD_OFFSET"
line.long 0 ""
  textline ""
  bitfld.long  0 20.--23. "          OFFSET_RANGE:modulation index range.           " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long  0 16.--19. " "	                                                      "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
; bitfld.long  0 15.      "          MODUL_DISABLE: disable modulation calculation. "  "enable,disable"
; textline ""
  bitfld.long  0 08.--10. "          OFFSET_GAIN: modulation index gain             "  "0,1,2,3,4,5,6,7"
  textline ""
  bitfld.long  0 04.--07. "          OFFSET_VALUE: output of modulation caluclator. "  "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long  0 00.--03. " "                                                          "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""

group 0x108--0x10b "DEMOD_WEIGHT"
 line.long 0 ""
  textline ""
  bitfld.long 0 28.      "          DEMOD_PHASE_GAIN: phase gain (IQ delay)      " "0,1"
  bitfld.long 0 24.--27. " "                                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
  bitfld.long 0 20.--23. "          DEMOD_WEIGHTING: FIT tap summing coefficient " "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 16.--19. " "                                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 12.--15. " "                                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 08.--11. " "                                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 04.--07. " "                                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  bitfld.long 0 00.--03. " "                                                       "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
  textline ""
tree.end

;=====================================================
tree "ADPCM    - Adaptive Differential Pulse Code Modulation"
;=====================================================
;-----------------------------------------------------
tree "NBADPCM1"
;-----------------------------------------------------
base a:0x08400000
group 00--04
line.word 0 "adp_status,ADPCM status register (covers all channels)"
base 0x00830004
group 00--04
line.word 0 "adp1_enc_conf,ADPCM channel 1 encoder configuration register"
base 0x00830008
group 00--04
line.word 0 "adp1_enc_in,ADPCM channel 1 encoder input register"
base 0x0083000C
group 00--04
line.word 0 "adp1_enc_out,ADPCM channel 1 encoder output register"
base 0x00830010
group 00--04
line.word 0 "adp_status,ADPCM status register (covers all channels)"
base 0x00830014
group 00--04
line.word 0 "adp1_dec_conf,ADPCM channel 1 decoder configuration register"
base 0x00830018
group 00--04
line.word 0 "adp1_dec_in,ADPCM channel 1 decoder input register"
base 0x0083001c
group 00--04
line.word 0 "adp1_dec_out,ADPCM channel 1 decoder output register"
tree.end

;-----------------------------------------------------
tree "NBADPCM2"
;-----------------------------------------------------
base a:0x08500000
group 00--04
line.word 0 "adp_status,ADPCM status register (covers all channels)"
base 0x00830004
group 00--04
line.word 0 "adp2_enc_conf,ADPCM channel 2 encoder configuration register"
base 0x00830008
group 00--04
line.word 0 "adp2_enc_in,ADPCM channel 2 encoder input register"
base 0x0083000C
group 00--04
line.word 0 "adp2_enc_out,ADPCM channel 2 encoder output register"
base 0x00830010
group 00--04
line.word 0 "adp_status,ADPCM status register (covers all channels)"
base 0x00830014
group 00--04
line.word 0 "adp2_dec_conf,ADPCM channel 2 decoder configuration register"
base 0x00830018
group 00--04
line.word 0 "adp2_dec_in,ADPCM channel 2 decoder input register"
base 0x0083001c
group 00--04
line.word 0 "adp2_dec_out,ADPCM channel 2 decoder output register"
tree.end

;-----------------------------------------------------
tree "WBADPCM"
;-----------------------------------------------------
base a:0x08600000
group 00--04
line.word 0 "adp_status,ADPCM status register (covers all channels)"
base 0x00830004
group 00--04
line.word 0 "adp3_enc_conf,ADPCM channel 3 encoder configuration register"
base 0x00830008
group 00--04
line.word 0 "adp3_enc_in,ADPCM channel 3 encoder input register"
base 0x0083000C
group 00--04
line.word 0 "adp3_enc_out,ADPCM channel 3 encoder output register"
base 0x00830010
group 00--04
line.word 0 "adp_status,ADPCM status register (covers all channels)"
base 0x00830014
group 00--04
line.word 0 "adp3_dec_conf,ADPCM channel 3 decoder configuration register"
base 0x00830018
group 00--04
line.word 0 "adp3_dec_in,ADPCM channel 3 decoder input register"
base 0x0083001c
group 00--04
line.word 0 "adp3_dec_out,ADPCM channel 3 decoder output register"
tree.end
tree.end

;=====================================================
tree "GDMAC    - Generic DMA Controller"
;=====================================================
base a:0x08800000
rgroup 0x000--0x003
 line.long 0 "CEMSR"
wgroup 0x004--0x007
 line.long 0 "CER"
wgroup 0x008--0x00B
 line.long 0 "CDR"
group 0x00C--0x00F
 line.long 0 "CTOR"
group 0x010--0x013
 line.long 0 "CCIER"
group 0x014--0x017
 line.long 0 "CDIER"
rgroup 0x018--0x01B
 line.long 0 "CCICR"
rgroup 0x01C--0x01F
 line.long 0 "CDICR"
wgroup 0x020--0x023
 line.long 0 "CCICLR"
wgroup 0x024--0x027
 line.long 0 "CDICLR"
group 0x028--0x02B
 line.long 0 "CRDR"
group 0x02C--0x02F
 line.long 0 "CTOENR"
group 0x030--0x033
 line.long 0 "CTERENR"
rgroup 0x034--0x037
 line.long 0 "CTOCR"
rgroup 0x038--0x03B
 line.long 0 "CTECR"
wgroup 0x03C--0x03F
 line.long 0 "CTOCLR"
wgroup 0x040--0x043
 line.long 0 "CTECLR"
group 0x044--0x047
 line.long 0 "CRCONF1"
group 0x048--0x04B
 line.long 0 "CRCONF2"
group 0x04C--0x04F
 line.long 0 "CRCONF3"
group 0x050--0x053
 line.long 0 "CRCONF4"
group 0x054--0x057
 line.long 0 "CRCONF5"
group 0x058--0x05B
 line.long 0 "CRCONF6"
group 0x05C--0x05F
 line.long 0 "CDPR"
group 0x060--0x063
 line.long 0 "C0DESCADR"
group 0x064--0x067
 line.long 0 "C1DESCADR"
group 0x068--0x06B
 line.long 0 "C2DESCADR"
group 0x06C--0x06F
 line.long 0 "C3DESCADR"
group 0x070--0x073
 line.long 0 "C4DESCADR"
group 0x074--0x077
 line.long 0 "C5DESCADR"
group 0x078--0x07B
 line.long 0 "C6DESCADR"
group 0x07C--0x07F
 line.long 0 "C7DESCADR"
group 0x080--0x083
 line.long 0 "C8DESCADR"
group 0x084--0x087
 line.long 0 "C9DESCADR"
group 0x088--0x08B
 line.long 0 "C10DESCADR"
group 0x08C--0x08F
 line.long 0 "C11DESCADR"
group 0x090--0x093
 line.long 0 "C12DESCADR"
group 0x094--0x097
 line.long 0 "C13DESCADR"
group 0x098--0x09B
 line.long 0 "C14DESCADR"
group 0x09C--0x09F
 line.long 0 "C15DESCADR"
group 0x0A0--0x0A3
 line.long 0 "C16DESCADR"
group 0x0A4--0x0A7
 line.long 0 "C17DESCADR"
group 0x0A8--0x0AB
 line.long 0 "C18DESCADR"
group 0x0AC--0x0AF
 line.long 0 "C19DESCADR"
group 0x0B0--0x0B3
 line.long 0 "C20DESCADR"
group 0x0B4--0x0B7
 line.long 0 "C21DESCADR"
group 0x0B8--0x0BB
 line.long 0 "C22DESCADR"
group 0x0BC--0x0BF
 line.long 0 "C23DESCADR"
group 0x0C0--0x0C3
 line.long 0 "C24DESCADR"
group 0x0C4--0x0C7
 line.long 0 "C25DESCADR"
group 0x0C8--0x0CB
 line.long 0 "C26DESCADR"
group 0x0CC--0x0CF
 line.long 0 "C27DESCADR"
group 0x0D0--0x0D3
 line.long 0 "C28DESCADR"
group 0x0D4--0x0D7
 line.long 0 "C29DESCADR"
group 0x0D8--0x0DB
 line.long 0 "C30DESCADR"
group 0x0DC--0x0DF
 line.long 0 "C31DESCADR"
rgroup 0x0E0--0x0E3
 line.long 0 "C0RTC"
rgroup 0x0E4--0x0E7
 line.long 0 "C1RTC"
rgroup 0x0E8--0x0EB
 line.long 0 "C2RTC"
rgroup 0x0EC--0x0EF
 line.long 0 "C3RTC"
rgroup 0x0F0--0x0F3
 line.long 0 "C4RTC"
rgroup 0x0F4--0x0F7
 line.long 0 "C5RTC"
rgroup 0x0F8--0x0FB
 line.long 0 "C6RTC"
rgroup 0x0FC--0x0FF
 line.long 0 "C7RTC"
rgroup 0x100--0x103
 line.long 0 "C8RTC"
rgroup 0x104--0x107
 line.long 0 "C9RTC"
rgroup 0x108--0x10B
 line.long 0 "C10RTC"
rgroup 0x10C--0x10F
 line.long 0 "C11RTC"
rgroup 0x110--0x113
 line.long 0 "C12RTC"
rgroup 0x114--0x117
 line.long 0 "C13RTC"
rgroup 0x118--0x11B
 line.long 0 "C14RTC"
rgroup 0x11C--0x11F
 line.long 0 "C15RTC"
rgroup 0x120--0x123
 line.long 0 "C16RTC"
rgroup 0x124--0x127
 line.long 0 "C17RTC"
rgroup 0x128--0x12B
 line.long 0 "C18RTC"
rgroup 0x12C--0x12F
 line.long 0 "C19RTC"
rgroup 0x130--0x133
 line.long 0 "C20RTC"
rgroup 0x134--0x137
 line.long 0 "C21RTC"
rgroup 0x138--0x13B
 line.long 0 "C22RTC"
rgroup 0x13C--0x13F
 line.long 0 "C23RTC"
rgroup 0x140--0x143
 line.long 0 "C24RTC"
rgroup 0x144--0x147
 line.long 0 "C25RTC"
rgroup 0x148--0x14B
 line.long 0 "C26RTC"
rgroup 0x14C--0x14F
 line.long 0 "C27RTC"
rgroup 0x150--0x153
 line.long 0 "C28RTC"
rgroup 0x154--0x157
 line.long 0 "C29RTC"
rgroup 0x158--0x15B
 line.long 0 "C30RTC"
rgroup 0x15C--0x15F
 line.long 0 "C31RTC"
rgroup 0x160--0x163
 line.long 0 "DBGFIFOLVL"
rgroup 0x164--0x167
 line.long 0 "DBGPORTA"
rgroup 0x168--0x16B
 line.long 0 "DBGPORTB"
rgroup 0x16C--0x16F
 line.long 0 "DBGFSM"
rgroup 0x170--0x17e
 line.long 0 "DBGSPARE"
tree.end

;=====================================================
tree "TMR      - General Purpose Timers"
;=====================================================
;-----------------------------------------------------
tree "CSS Timer 1"
;-----------------------------------------------------
base a:0x08900000
group 0x000--0x003
 line.long 0 "TMR1LOAD"
rgroup 0x004--0x007
 line.long 0 "TMR1VALUE"
group 0x008--0x00B
 line.long 0 "TMR1CONTROL"
  textline ""
  bitfld.long 0 7. "    Timer Enable     ," " disabled, enabled "
  textline ""
  bitfld.long 0 6. "    Timer Mode       ,"," periodic, free running "
  textline ""
  bitfld.long 0 5. "    Interrupt Enable ,"," disabled, enabled "
  textline ""
  bitfld.long 0 2.--3. "    Prescale bits     ,","0 stages (clock is divided by 1), 4 stages (clock is divided by 16), 8 stages (clock is divided by 256), undefined (do not use)"
  textline ""
  bitfld.long 0 1. "    Timer Size       ,"," 16-bit counter, 32-bit counter "
  textline ""
  bitfld.long 0 0. "    One Shot Count   ,"," wrapping mode, one-shot mode "
wgroup 0x00C--0x00F
 hide.long 0 "TMR1INTCLR"
rgroup 0x010--0x013
 line.long 0 "TMR1RIS"
rgroup 0x014--0x017
 line.long 0 "TMR1MIS"
group 0x018--0x01B
 line.long 0 "TMR1BGLOAD"
tree.end

;-----------------------------------------------------
tree "CSS Timer 2"
;-----------------------------------------------------
group 0x020--0x023
 line.long 0 "TMR2LOAD"
rgroup 0x024--0x027
 line.long 0 "TMR2VALUE"
group 0x028--0x02B
 line.long 0 "TMR2CONTROL"
  textline ""
  bitfld.long 0 7. "    Timer Enable     ," " disabled, enabled "
  textline ""
  bitfld.long 0 6. "    Timer Mode       ,"," periodic, free running "
  textline ""
  bitfld.long 0 5. "    Interrupt Enable ,"," disabled, enabled "
  textline ""
  bitfld.long 0 2.--3. "    Prescale bits     ,","0 stages (clock is divided by 1), 4 stages (clock is divided by 16), 8 stages (clock is divided by 256), undefined (do not use)"
  textline ""
  bitfld.long 0 1. "    Timer Size       ,"," 16-bit counter, 32-bit counter "
  textline ""
  bitfld.long 0 0. "    One Shot Count   ,"," wrapping mode, one-shot mode "
wgroup 0x02C--0x02F
 hide.long 0 "TMR2INTCLR"
rgroup 0x030--0x033
 line.long 0 "TMR2RIS"
rgroup 0x034--0x037
 line.long 0 "TMR2MIS"
group 0x038--0x03B
 line.long 0 "TMR2BGLOAD"
tree.end

;-----------------------------------------------------
tree "Cortex Timer 0"
;-----------------------------------------------------
base a:0x05800000
group 0x000--0x003
 line.long 0 "TMR3LOAD"
rgroup 0x004--0x007
 line.long 0 "TMR3VALUE"
group 0x008--0x00B
 line.long 0 "TMR3CONTROL"
  textline ""
  bitfld.long 0 7. "    Timer Enable     ," " disabled, enabled "
  textline ""
  bitfld.long 0 6. "    Timer Mode       ,"," periodic, free running "
  textline ""
  bitfld.long 0 5. "    Interrupt Enable ,"," disabled, enabled "
  textline ""
  bitfld.long 0 2.--3. "    Prescale bits     ,","0 stages (clock is divided by 1), 4 stages (clock is divided by 16), 8 stages (clock is divided by 256), undefined (do not use)"
  textline ""
  bitfld.long 0 1. "    Timer Size       ,"," 16-bit counter, 32-bit counter "
  textline ""
  bitfld.long 0 0. "    One Shot Count   ,"," wrapping mode, one-shot mode "
wgroup 0x00C--0x00F
 hide.long 0 "TMR3INTCLR"
rgroup 0x010--0x013
 line.long 0 "TMR3RIS"
rgroup 0x014--0x017
 line.long 0 "TMR3MIS"
group 0x018--0x01B
 line.long 0 "TMR3BGLOAD"
tree.end

;-----------------------------------------------------
tree "Cortex Timer 1"
;-----------------------------------------------------
group 0x020--0x023
 line.long 0 "TMR4LOAD"
rgroup 0x024--0x027
 line.long 0 "TMR4VALUE"
group 0x028--0x02B
 line.long 0 "TMR4CONTROL"
  textline ""
  bitfld.long 0 7. "    Timer Enable     ," " disabled, enabled "
  textline ""
  bitfld.long 0 6. "    Timer Mode       ,"," periodic, free running "
  textline ""
  bitfld.long 0 5. "    Interrupt Enable ,"," disabled, enabled "
  textline ""
  bitfld.long 0 2.--3. "    Prescale bits     ,","0 stages (clock is divided by 1), 4 stages (clock is divided by 16), 8 stages (clock is divided by 256), undefined (do not use)"
  textline ""
  bitfld.long 0 1. "    Timer Size       ,"," 16-bit counter, 32-bit counter "
  textline ""
  bitfld.long 0 0. "    One Shot Count   ,"," wrapping mode, one-shot mode "
wgroup 0x02C--0x02F
 hide.long 0 "TMR4INTCLR"
rgroup 0x030--0x033
 line.long 0 "TMR4RIS"
rgroup 0x034--0x037
 line.long 0 "TMR4MIS"
group 0x038--0x03B
 line.long 0 "TMR4BGLOAD"
tree.end
tree.end

;=====================================================
tree "PLICU    - Priority Level Interrupt Control Unit"
;=====================================================
base a:0x08a00000
tree.close "CH_EDGE_LEVEL1"
group 0x008--0x00b
  textline ""
  bitfld.long 0  0. "    KPD                 ," "level,edge"
  textline ""
  bitfld.long 0  1. "    SEC                 ," "level,edge"
  textline ""
  bitfld.long 0  2. "    GDMAC_ERR           ," "level,edge"
  textline ""
  bitfld.long 0  3. "    GDMAC_DMA           ," "level,edge"
  textline ""
  bitfld.long 0  4. "    RCNTRL              ," "level,edge"
  textline ""
  bitfld.long 0  5. "    EXTERNAL_REQUEST0   ," "level,edge"
  textline ""
  bitfld.long 0  6. "    EXTERNAL_REQUEST1   ," "level,edge"
  textline ""
  bitfld.long 0  7. "    EXTERNAL_REQUEST2   ," "level,edge"
  textline ""
  bitfld.long 0  8. "    EXTERNAL_REQUEST3   ," "level,edge"
  textline ""
  bitfld.long 0  9. "    EXTERNAL_REQUEST4   ," "level,edge"
  textline ""
  bitfld.long 0 10. "    EXTERNAL_REQUEST5   ," "level,edge"
  textline ""
  bitfld.long 0 11. "    EXTERNAL_REQUEST6   ," "level,edge"
  textline ""
  bitfld.long 0 12. "    EXTERNAL_REQUEST7   ," "level,edge"
  textline ""
  bitfld.long 0 13. "    EXTERNAL_REQUEST8   ," "level,edge"
  textline ""
  bitfld.long 0 14. "    EXTERNAL_REQUEST9   ," "level,edge"
  textline ""
  bitfld.long 0 15. "    SW1                 ," "level,edge"
  textline ""
  bitfld.long 0 16. "    EXTERNAL_REQUEST10  ," "level,edge"
  textline ""
  bitfld.long 0 17. "    EXTERNAL_REQUEST11  ," "level,edge"
  textline ""
  bitfld.long 0 18. "    EXTERNAL_REQUEST12  ," "level,edge"
  textline ""
  bitfld.long 0 19. "    EXTERNAL_REQUEST13  ," "level,edge"
  textline ""
  bitfld.long 0 20. "    EXTERNAL_REQUEST14  ," "level,edge"
  textline ""
  bitfld.long 0 21. "    EXTERNAL_REQUEST15  ," "level,edge"
  textline ""
  bitfld.long 0 22. "    WADPCM              ," "level,edge"
  textline ""
  bitfld.long 0 23. "    ADPCM2              ," "level,edge"
  textline ""
  bitfld.long 0 24. "    ADPCM1              ," "level,edge"
  textline ""
  bitfld.long 0 25. "    RTC                 ," "level,edge"
  textline ""
  bitfld.long 0 26. "    APB_TIMER3          ," "level,edge"
  textline ""
  bitfld.long 0 27. "    APB_TIMER2          ," "level,edge"
  textline ""
  bitfld.long 0 28. "    APB_TIMER1          ," "level,edge"
  textline ""
  bitfld.long 0 29. "    TDM3                ," "level,edge"
  textline ""
  bitfld.long 0 30. "    TDM2                ," "level,edge"
  textline ""
  bitfld.long 0 31. "    SW2                 ," "level,edge"
tree.end
tree.close "CH_EDGE_LEVEL2"
group 0x00c--0x00f
  textline ""
  bitfld.long 0  0. "    TDM1                ," "level,edge"
  textline ""
  bitfld.long 0  1. "    SPI2                ," "level,edge"
  textline ""
  bitfld.long 0  2. "    SPI1                ," "level,edge"
  textline ""
  bitfld.long 0  3. "    CSS_TIMER1          ," "level,edge"
  textline ""
  bitfld.long 0  4. "    UART3               ," "level,edge"
  textline ""
  bitfld.long 0  5. "    UART2               ," "level,edge"
  textline ""
  bitfld.long 0  6. "    UART1               ," "level,edge"
  textline ""
  bitfld.long 0  7. "    I2C2                ," "level,edge"
  textline ""
  bitfld.long 0  8. "    I2C1                ," "level,edge"
  textline ""
  bitfld.long 0  9. "    CSS_TIMER0          ," "level,edge"
  textline ""
  bitfld.long 0 10. "    BMP_BCNT1           ," "level,edge"
  textline ""
  bitfld.long 0 11. "    BMP_BCNT0           ," "level,edge"
  textline ""
  bitfld.long 0 12. "    BMP_MCU_IRQ1        ," "level,edge"
  textline ""
  bitfld.long 0 13. "    BMP_BMPTIME         ," "level,edge"
  textline ""
  bitfld.long 0 14. "    BMP_MCU_IRQ0        ," "level,edge"
  textline ""
  bitfld.long 0 15. "    SW3                 ," "level,edge"
  textline ""
  bitfld.long 0 16. "    BMP_RCU_IRQ         ," "level,edge"
  textline ""
  bitfld.long 0 17. "    BMP_TCU_IRQ         ," "level,edge"
  textline ""
  bitfld.long 0 18. "    BMP_SYNC_DET        ," "level,edge"
  textline ""
  bitfld.long 0 19. "    BMP_BCNT_S1         ," "level,edge"
  textline ""
  bitfld.long 0 20. "    BMP_BCNT_S0         ," "level,edge"
  textline ""
  bitfld.long 0 21. "    PACP                ," "level,edge"
  textline ""
  bitfld.long 0 22. "    BMP_FSI             ," "level,edge"
  textline ""
  bitfld.long 0 23. "    BMP_MCU_FIQ0        ," "level,edge"
  textline ""
  bitfld.long 0 24. "    BMP_SIF             ," "level,edge"
  textline ""
  bitfld.long 0 25. "    BMP_RFCU            ," "level,edge"
  textline ""
  bitfld.long 0 26. "    BMP_MCU_FIQ1        ," "level,edge"
  textline ""
  bitfld.long 0 27. "    BMP_TCU_FIQ         ," "level,edge"
  textline ""
  bitfld.long 0 28. "    BMP_RCU_FIQ         ," "level,edge"
  textline ""
  bitfld.long 0 29. "    BMP_TBUF_EMP        ," "level,edge"
  textline ""
  bitfld.long 0 30. "    BMP_RBUF_FULL       ," "level,edge"
  textline ""
  bitfld.long 0 31. "    SW4                 ," "level,edge"
tree.end
wgroup 0x010--0x013
 textline ""
 hide.long 0 "CH_SW_TRIG_SET1"
wgroup 0x014--0x017
 hide.long 0 "CH_SW_TRIG_SET2"

tree.close "SW_CH_REQ"
wgroup 0x018--0x01b
  textline "SWINT1    "
  button "trigger" "D.S 0x08a00018 %LE %LONG (1.<<0.)"
  textline "SWINT2    "
  button "trigger" "D.S 0x08a00018 %LE %LONG (1.<<1.)"
  textline "SWINT3    "
  button "trigger" "D.S 0x08a00018 %LE %LONG (1.<<2.)"
  textline "SWINT4    "
  button "trigger" "D.S 0x08a00018 %LE %LONG (1.<<3.)"
tree.end

tree.close "STATUS1"
rgroup 0x01c--0x01f
  textline ""
  bitfld.long 0  0. "    KPD                 ," "not_pending,pending"
  textline ""
  bitfld.long 0  1. "    SEC                 ," "not_pending,pending"
  textline ""
  bitfld.long 0  2. "    GDMAC_ERR           ," "not_pending,pending"
  textline ""
  bitfld.long 0  3. "    GDMAC_DMA           ," "not_pending,pending"
  textline ""
  bitfld.long 0  4. "    RCNTRL              ," "not_pending,pending"
  textline ""
  bitfld.long 0  5. "    EXTERNAL_REQUEST0   ," "not_pending,pending"
  textline ""
  bitfld.long 0  6. "    EXTERNAL_REQUEST1   ," "not_pending,pending"
  textline ""
  bitfld.long 0  7. "    EXTERNAL_REQUEST2   ," "not_pending,pending"
  textline ""
  bitfld.long 0  8. "    EXTERNAL_REQUEST3   ," "not_pending,pending"
  textline ""
  bitfld.long 0  9. "    EXTERNAL_REQUEST4   ," "not_pending,pending"
  textline ""
  bitfld.long 0 10. "    EXTERNAL_REQUEST5   ," "not_pending,pending"
  textline ""
  bitfld.long 0 11. "    EXTERNAL_REQUEST6   ," "not_pending,pending"
  textline ""
  bitfld.long 0 12. "    EXTERNAL_REQUEST7   ," "not_pending,pending"
  textline ""
  bitfld.long 0 13. "    EXTERNAL_REQUEST8   ," "not_pending,pending"
  textline ""
  bitfld.long 0 14. "    EXTERNAL_REQUEST9   ," "not_pending,pending"
  textline ""
  bitfld.long 0 15. "    SW1                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 16. "    EXTERNAL_REQUEST10  ," "not_pending,pending"
  textline ""
  bitfld.long 0 17. "    EXTERNAL_REQUEST11  ," "not_pending,pending"
  textline ""
  bitfld.long 0 18. "    EXTERNAL_REQUEST12  ," "not_pending,pending"
  textline ""
  bitfld.long 0 19. "    EXTERNAL_REQUEST13  ," "not_pending,pending"
  textline ""
  bitfld.long 0 20. "    EXTERNAL_REQUEST14  ," "not_pending,pending"
  textline ""
  bitfld.long 0 21. "    EXTERNAL_REQUEST15  ," "not_pending,pending"
  textline ""
  bitfld.long 0 22. "    WADPCM              ," "not_pending,pending"
  textline ""
  bitfld.long 0 23. "    ADPCM2              ," "not_pending,pending"
  textline ""
  bitfld.long 0 24. "    ADPCM1              ," "not_pending,pending"
  textline ""
  bitfld.long 0 25. "    RTC                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 26. "    APB_TIMER3          ," "not_pending,pending"
  textline ""
  bitfld.long 0 27. "    APB_TIMER2          ," "not_pending,pending"
  textline ""
  bitfld.long 0 28. "    APB_TIMER1          ," "not_pending,pending"
  textline ""
  bitfld.long 0 29. "    TDM3                ," "not_pending,pending"
  textline ""
  bitfld.long 0 30. "    TDM2                ," "not_pending,pending"
  textline ""
  bitfld.long 0 31. "    SW2                 ," "not_pending,pending"
tree.end
tree.close "STATUS2"
rgroup 0x020--0x023
  textline ""
  bitfld.long 0  0. "    TDM1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  1. "    SPI2                ," "not_pending,pending"
  textline ""
  bitfld.long 0  2. "    SPI1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  3. "    CSS_TIMER1          ," "not_pending,pending"
  textline ""
  bitfld.long 0  4. "    UART3               ," "not_pending,pending"
  textline ""
  bitfld.long 0  5. "    UART2               ," "not_pending,pending"
  textline ""
  bitfld.long 0  6. "    UART1               ," "not_pending,pending"
  textline ""
  bitfld.long 0  7. "    I2C2                ," "not_pending,pending"
  textline ""
  bitfld.long 0  8. "    I2C1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  9. "    CSS_TIMER0          ," "not_pending,pending"
  textline ""
  bitfld.long 0 10. "    BMP_BCNT1           ," "not_pending,pending"
  textline ""
  bitfld.long 0 11. "    BMP_BCNT0           ," "not_pending,pending"
  textline ""
  bitfld.long 0 12. "    BMP_MCU_IRQ1        ," "not_pending,pending"
  textline ""
  bitfld.long 0 13. "    BMP_BMPTIME         ," "not_pending,pending"
  textline ""
  bitfld.long 0 14. "    BMP_MCU_IRQ0        ," "not_pending,pending"
  textline ""
  bitfld.long 0 15. "    SW3                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 16. "    BMP_RCU_IRQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 17. "    BMP_TCU_IRQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 18. "    BMP_SYNC_DET        ," "not_pending,pending"
  textline ""
  bitfld.long 0 19. "    BMP_BCNT_S1         ," "not_pending,pending"
  textline ""
  bitfld.long 0 20. "    BMP_BCNT_S0         ," "not_pending,pending"
  textline ""
  bitfld.long 0 21. "    PACP                ," "not_pending,pending"
  textline ""
  bitfld.long 0 22. "    BMP_FSI             ," "not_pending,pending"
  textline ""
  bitfld.long 0 23. "    BMP_MCU_FIQ0        ," "not_pending,pending"
  textline ""
  bitfld.long 0 24. "    BMP_SIF             ," "not_pending,pending"
  textline ""
  bitfld.long 0 25. "    BMP_RFCU            ," "not_pending,pending"
  textline ""
  bitfld.long 0 26. "    BMP_MCU_FIQ1        ," "not_pending,pending"
  textline ""
  bitfld.long 0 27. "    BMP_TCU_FIQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 28. "    BMP_RCU_FIQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 29. "    BMP_TBUF_EMP        ," "not_pending,pending"
  textline ""
  bitfld.long 0 30. "    BMP_RBUF_FULL       ," "not_pending,pending"
  textline ""
  bitfld.long 0 31. "    SW4                 ," "not_pending,pending"
tree.end
tree.close "PENDING_REQ1"
rgroup 0x024--0x027
  textline ""
  bitfld.long 0  0. "    KPD                 ," "not_pending,pending"
  textline ""
  bitfld.long 0  1. "    SEC                 ," "not_pending,pending"
  textline ""
  bitfld.long 0  2. "    GDMAC_ERR           ," "not_pending,pending"
  textline ""
  bitfld.long 0  3. "    GDMAC_DMA           ," "not_pending,pending"
  textline ""
  bitfld.long 0  4. "    RCNTRL              ," "not_pending,pending"
  textline ""
  bitfld.long 0  5. "    EXTERNAL_REQUEST0   ," "not_pending,pending"
  textline ""
  bitfld.long 0  6. "    EXTERNAL_REQUEST1   ," "not_pending,pending"
  textline ""
  bitfld.long 0  7. "    EXTERNAL_REQUEST2   ," "not_pending,pending"
  textline ""
  bitfld.long 0  8. "    EXTERNAL_REQUEST3   ," "not_pending,pending"
  textline ""
  bitfld.long 0  9. "    EXTERNAL_REQUEST4   ," "not_pending,pending"
  textline ""
  bitfld.long 0 10. "    EXTERNAL_REQUEST5   ," "not_pending,pending"
  textline ""
  bitfld.long 0 11. "    EXTERNAL_REQUEST6   ," "not_pending,pending"
  textline ""
  bitfld.long 0 12. "    EXTERNAL_REQUEST7   ," "not_pending,pending"
  textline ""
  bitfld.long 0 13. "    EXTERNAL_REQUEST8   ," "not_pending,pending"
  textline ""
  bitfld.long 0 14. "    EXTERNAL_REQUEST9   ," "not_pending,pending"
  textline ""
  bitfld.long 0 15. "    SW1                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 16. "    EXTERNAL_REQUEST10  ," "not_pending,pending"
  textline ""
  bitfld.long 0 17. "    EXTERNAL_REQUEST11  ," "not_pending,pending"
  textline ""
  bitfld.long 0 18. "    EXTERNAL_REQUEST12  ," "not_pending,pending"
  textline ""
  bitfld.long 0 19. "    EXTERNAL_REQUEST13  ," "not_pending,pending"
  textline ""
  bitfld.long 0 20. "    EXTERNAL_REQUEST14  ," "not_pending,pending"
  textline ""
  bitfld.long 0 21. "    EXTERNAL_REQUEST15  ," "not_pending,pending"
  textline ""
  bitfld.long 0 22. "    WADPCM              ," "not_pending,pending"
  textline ""
  bitfld.long 0 23. "    ADPCM2              ," "not_pending,pending"
  textline ""
  bitfld.long 0 24. "    ADPCM1              ," "not_pending,pending"
  textline ""
  bitfld.long 0 25. "    RTC                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 26. "    APB_TIMER3          ," "not_pending,pending"
  textline ""
  bitfld.long 0 27. "    APB_TIMER2          ," "not_pending,pending"
  textline ""
  bitfld.long 0 28. "    APB_TIMER1          ," "not_pending,pending"
  textline ""
  bitfld.long 0 29. "    TDM3                ," "not_pending,pending"
  textline ""
  bitfld.long 0 30. "    TDM2                ," "not_pending,pending"
  textline ""
  bitfld.long 0 31. "    SW2                 ," "not_pending,pending"
tree.end
tree.close "PENDING_REQ2"
rgroup 0x028--0x02b
  textline ""
  bitfld.long 0  0. "    TDM1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  1. "    SPI2                ," "not_pending,pending"
  textline ""
  bitfld.long 0  2. "    SPI1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  3. "    CSS_TIMER1          ," "not_pending,pending"
  textline ""
  bitfld.long 0  4. "    UART3               ," "not_pending,pending"
  textline ""
  bitfld.long 0  5. "    UART2               ," "not_pending,pending"
  textline ""
  bitfld.long 0  6. "    UART1               ," "not_pending,pending"
  textline ""
  bitfld.long 0  7. "    I2C2                ," "not_pending,pending"
  textline ""
  bitfld.long 0  8. "    I2C1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  9. "    CSS_TIMER0          ," "not_pending,pending"
  textline ""
  bitfld.long 0 10. "    BMP_BCNT1           ," "not_pending,pending"
  textline ""
  bitfld.long 0 11. "    BMP_BCNT0           ," "not_pending,pending"
  textline ""
  bitfld.long 0 12. "    BMP_MCU_IRQ1        ," "not_pending,pending"
  textline ""
  bitfld.long 0 13. "    BMP_BMPTIME         ," "not_pending,pending"
  textline ""
  bitfld.long 0 14. "    BMP_MCU_IRQ0        ," "not_pending,pending"
  textline ""
  bitfld.long 0 15. "    SW3                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 16. "    BMP_RCU_IRQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 17. "    BMP_TCU_IRQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 18. "    BMP_SYNC_DET        ," "not_pending,pending"
  textline ""
  bitfld.long 0 19. "    BMP_BCNT_S1         ," "not_pending,pending"
  textline ""
  bitfld.long 0 20. "    BMP_BCNT_S0         ," "not_pending,pending"
  textline ""
  bitfld.long 0 21. "    PACP                ," "not_pending,pending"
  textline ""
  bitfld.long 0 22. "    BMP_FSI             ," "not_pending,pending"
  textline ""
  bitfld.long 0 23. "    BMP_MCU_FIQ0        ," "not_pending,pending"
  textline ""
  bitfld.long 0 24. "    BMP_SIF             ," "not_pending,pending"
  textline ""
  bitfld.long 0 25. "    BMP_RFCU            ," "not_pending,pending"
  textline ""
  bitfld.long 0 26. "    BMP_MCU_FIQ1        ," "not_pending,pending"
  textline ""
  bitfld.long 0 27. "    BMP_TCU_FIQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 28. "    BMP_RCU_FIQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 29. "    BMP_TBUF_EMP        ," "not_pending,pending"
  textline ""
  bitfld.long 0 30. "    BMP_RBUF_FULL       ," "not_pending,pending"
  textline ""
  bitfld.long 0 31. "    SW4                 ," "not_pending,pending"
tree.end
tree.close "CAUSE1"
rgroup 0x02c--0x02f
  textline ""
  bitfld.long 0  0. "    KPD                 ," "not_pending,pending"
  textline ""
  bitfld.long 0  1. "    SEC                 ," "not_pending,pending"
  textline ""
  bitfld.long 0  2. "    GDMAC_ERR           ," "not_pending,pending"
  textline ""
  bitfld.long 0  3. "    GDMAC_DMA           ," "not_pending,pending"
  textline ""
  bitfld.long 0  4. "    RCNTRL              ," "not_pending,pending"
  textline ""
  bitfld.long 0  5. "    EXTERNAL_REQUEST0   ," "not_pending,pending"
  textline ""
  bitfld.long 0  6. "    EXTERNAL_REQUEST1   ," "not_pending,pending"
  textline ""
  bitfld.long 0  7. "    EXTERNAL_REQUEST2   ," "not_pending,pending"
  textline ""
  bitfld.long 0  8. "    EXTERNAL_REQUEST3   ," "not_pending,pending"
  textline ""
  bitfld.long 0  9. "    EXTERNAL_REQUEST4   ," "not_pending,pending"
  textline ""
  bitfld.long 0 10. "    EXTERNAL_REQUEST5   ," "not_pending,pending"
  textline ""
  bitfld.long 0 11. "    EXTERNAL_REQUEST6   ," "not_pending,pending"
  textline ""
  bitfld.long 0 12. "    EXTERNAL_REQUEST7   ," "not_pending,pending"
  textline ""
  bitfld.long 0 13. "    EXTERNAL_REQUEST8   ," "not_pending,pending"
  textline ""
  bitfld.long 0 14. "    EXTERNAL_REQUEST9   ," "not_pending,pending"
  textline ""
  bitfld.long 0 15. "    SW1                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 16. "    EXTERNAL_REQUEST10  ," "not_pending,pending"
  textline ""
  bitfld.long 0 17. "    EXTERNAL_REQUEST11  ," "not_pending,pending"
  textline ""
  bitfld.long 0 18. "    EXTERNAL_REQUEST12  ," "not_pending,pending"
  textline ""
  bitfld.long 0 19. "    EXTERNAL_REQUEST13  ," "not_pending,pending"
  textline ""
  bitfld.long 0 20. "    EXTERNAL_REQUEST14  ," "not_pending,pending"
  textline ""
  bitfld.long 0 21. "    EXTERNAL_REQUEST15  ," "not_pending,pending"
  textline ""
  bitfld.long 0 22. "    WADPCM              ," "not_pending,pending"
  textline ""
  bitfld.long 0 23. "    ADPCM2              ," "not_pending,pending"
  textline ""
  bitfld.long 0 24. "    ADPCM1              ," "not_pending,pending"
  textline ""
  bitfld.long 0 25. "    RTC                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 26. "    APB_TIMER3          ," "not_pending,pending"
  textline ""
  bitfld.long 0 27. "    APB_TIMER2          ," "not_pending,pending"
  textline ""
  bitfld.long 0 28. "    APB_TIMER1          ," "not_pending,pending"
  textline ""
  bitfld.long 0 29. "    TDM3                ," "not_pending,pending"
  textline ""
  bitfld.long 0 30. "    TDM2                ," "not_pending,pending"
  textline ""
  bitfld.long 0 31. "    SW2                 ," "not_pending,pending"
tree.end
tree.close "CAUSE2"
rgroup 0x030--0x033
  textline ""
  bitfld.long 0  0. "    TDM1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  1. "    SPI2                ," "not_pending,pending"
  textline ""
  bitfld.long 0  2. "    SPI1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  3. "    CSS_TIMER1          ," "not_pending,pending"
  textline ""
  bitfld.long 0  4. "    UART3               ," "not_pending,pending"
  textline ""
  bitfld.long 0  5. "    UART2               ," "not_pending,pending"
  textline ""
  bitfld.long 0  6. "    UART1               ," "not_pending,pending"
  textline ""
  bitfld.long 0  7. "    I2C2                ," "not_pending,pending"
  textline ""
  bitfld.long 0  8. "    I2C1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  9. "    CSS_TIMER0          ," "not_pending,pending"
  textline ""
  bitfld.long 0 10. "    BMP_BCNT1           ," "not_pending,pending"
  textline ""
  bitfld.long 0 11. "    BMP_BCNT0           ," "not_pending,pending"
  textline ""
  bitfld.long 0 12. "    BMP_MCU_IRQ1        ," "not_pending,pending"
  textline ""
  bitfld.long 0 13. "    BMP_BMPTIME         ," "not_pending,pending"
  textline ""
  bitfld.long 0 14. "    BMP_MCU_IRQ0        ," "not_pending,pending"
  textline ""
  bitfld.long 0 15. "    SW3                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 16. "    BMP_RCU_IRQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 17. "    BMP_TCU_IRQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 18. "    BMP_SYNC_DET        ," "not_pending,pending"
  textline ""
  bitfld.long 0 19. "    BMP_BCNT_S1         ," "not_pending,pending"
  textline ""
  bitfld.long 0 20. "    BMP_BCNT_S0         ," "not_pending,pending"
  textline ""
  bitfld.long 0 21. "    PACP                ," "not_pending,pending"
  textline ""
  bitfld.long 0 22. "    BMP_FSI             ," "not_pending,pending"
  textline ""
  bitfld.long 0 23. "    BMP_MCU_FIQ0        ," "not_pending,pending"
  textline ""
  bitfld.long 0 24. "    BMP_SIF             ," "not_pending,pending"
  textline ""
  bitfld.long 0 25. "    BMP_RFCU            ," "not_pending,pending"
  textline ""
  bitfld.long 0 26. "    BMP_MCU_FIQ1        ," "not_pending,pending"
  textline ""
  bitfld.long 0 27. "    BMP_TCU_FIQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 28. "    BMP_RCU_FIQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 29. "    BMP_TBUF_EMP        ," "not_pending,pending"
  textline ""
  bitfld.long 0 30. "    BMP_RBUF_FULL       ," "not_pending,pending"
  textline ""
  bitfld.long 0 31. "    SW4                 ," "not_pending,pending"
tree.end
tree.close "CH_MASK1"
rgroup 0x034--0x037
  textline ""
  bitfld.long 0  0. "    KPD                 ," "disabled,enabled"
  textline ""
  bitfld.long 0  1. "    SEC                 ," "disabled,enabled"
  textline ""
  bitfld.long 0  2. "    GDMAC_ERR           ," "disabled,enabled"
  textline ""
  bitfld.long 0  3. "    GDMAC_DMA           ," "disabled,enabled"
  textline ""
  bitfld.long 0  4. "    RCNTRL              ," "disabled,enabled"
  textline ""
  bitfld.long 0  5. "    EXTERNAL_REQUEST0   ," "disabled,enabled"
  textline ""
  bitfld.long 0  6. "    EXTERNAL_REQUEST1   ," "disabled,enabled"
  textline ""
  bitfld.long 0  7. "    EXTERNAL_REQUEST2   ," "disabled,enabled"
  textline ""
  bitfld.long 0  8. "    EXTERNAL_REQUEST3   ," "disabled,enabled"
  textline ""
  bitfld.long 0  9. "    EXTERNAL_REQUEST4   ," "disabled,enabled"
  textline ""
  bitfld.long 0 10. "    EXTERNAL_REQUEST5   ," "disabled,enabled"
  textline ""
  bitfld.long 0 11. "    EXTERNAL_REQUEST6   ," "disabled,enabled"
  textline ""
  bitfld.long 0 12. "    EXTERNAL_REQUEST7   ," "disabled,enabled"
  textline ""
  bitfld.long 0 13. "    EXTERNAL_REQUEST8   ," "disabled,enabled"
  textline ""
  bitfld.long 0 14. "    EXTERNAL_REQUEST9   ," "disabled,enabled"
  textline ""
  bitfld.long 0 15. "    SW1                 ," "disabled,enabled"
  textline ""
  bitfld.long 0 16. "    EXTERNAL_REQUEST10  ," "disabled,enabled"
  textline ""
  bitfld.long 0 17. "    EXTERNAL_REQUEST11  ," "disabled,enabled"
  textline ""
  bitfld.long 0 18. "    EXTERNAL_REQUEST12  ," "disabled,enabled"
  textline ""
  bitfld.long 0 19. "    EXTERNAL_REQUEST13  ," "disabled,enabled"
  textline ""
  bitfld.long 0 20. "    EXTERNAL_REQUEST14  ," "disabled,enabled"
  textline ""
  bitfld.long 0 21. "    EXTERNAL_REQUEST15  ," "disabled,enabled"
  textline ""
  bitfld.long 0 22. "    WADPCM              ," "disabled,enabled"
  textline ""
  bitfld.long 0 23. "    ADPCM2              ," "disabled,enabled"
  textline ""
  bitfld.long 0 24. "    ADPCM1              ," "disabled,enabled"
  textline ""
  bitfld.long 0 25. "    RTC                 ," "disabled,enabled"
  textline ""
  bitfld.long 0 26. "    APB_TIMER3          ," "disabled,enabled"
  textline ""
  bitfld.long 0 27. "    APB_TIMER2          ," "disabled,enabled"
  textline ""
  bitfld.long 0 28. "    APB_TIMER1          ," "disabled,enabled"
  textline ""
  bitfld.long 0 29. "    TDM3                ," "disabled,enabled"
  textline ""
  bitfld.long 0 30. "    TDM2                ," "disabled,enabled"
  textline ""
  bitfld.long 0 31. "    SW2                 ," "disabled,enabled"
tree.end
tree.close "CH_MASK2"
rgroup 0x038--0x03b
  textline ""
  bitfld.long 0  0. "    TDM1                ," "disabled,enabled"
  textline ""
  bitfld.long 0  1. "    SPI2                ," "disabled,enabled"
  textline ""
  bitfld.long 0  2. "    SPI1                ," "disabled,enabled"
  textline ""
  bitfld.long 0  3. "    CSS_TIMER1          ," "disabled,enabled"
  textline ""
  bitfld.long 0  4. "    UART3               ," "disabled,enabled"
  textline ""
  bitfld.long 0  5. "    UART2               ," "disabled,enabled"
  textline ""
  bitfld.long 0  6. "    UART1               ," "disabled,enabled"
  textline ""
  bitfld.long 0  7. "    I2C2                ," "disabled,enabled"
  textline ""
  bitfld.long 0  8. "    I2C1                ," "disabled,enabled"
  textline ""
  bitfld.long 0  9. "    CSS_TIMER0          ," "disabled,enabled"
  textline ""
  bitfld.long 0 10. "    BMP_BCNT1           ," "disabled,enabled"
  textline ""
  bitfld.long 0 11. "    BMP_BCNT0           ," "disabled,enabled"
  textline ""
  bitfld.long 0 12. "    BMP_MCU_IRQ1        ," "disabled,enabled"
  textline ""
  bitfld.long 0 13. "    BMP_BMPTIME         ," "disabled,enabled"
  textline ""
  bitfld.long 0 14. "    BMP_MCU_IRQ0        ," "disabled,enabled"
  textline ""
  bitfld.long 0 15. "    SW3                 ," "disabled,enabled"
  textline ""
  bitfld.long 0 16. "    BMP_RCU_IRQ         ," "disabled,enabled"
  textline ""
  bitfld.long 0 17. "    BMP_TCU_IRQ         ," "disabled,enabled"
  textline ""
  bitfld.long 0 18. "    BMP_SYNC_DET        ," "disabled,enabled"
  textline ""
  bitfld.long 0 19. "    BMP_BCNT_S1         ," "disabled,enabled"
  textline ""
  bitfld.long 0 20. "    BMP_BCNT_S0         ," "disabled,enabled"
  textline ""
  bitfld.long 0 21. "    PACP                ," "disabled,enabled"
  textline ""
  bitfld.long 0 22. "    BMP_FSI             ," "disabled,enabled"
  textline ""
  bitfld.long 0 23. "    BMP_MCU_FIQ0        ," "disabled,enabled"
  textline ""
  bitfld.long 0 24. "    BMP_SIF             ," "disabled,enabled"
  textline ""
  bitfld.long 0 25. "    BMP_RFCU            ," "disabled,enabled"
  textline ""
  bitfld.long 0 26. "    BMP_MCU_FIQ1        ," "disabled,enabled"
  textline ""
  bitfld.long 0 27. "    BMP_TCU_FIQ         ," "disabled,enabled"
  textline ""
  bitfld.long 0 28. "    BMP_RCU_FIQ         ," "disabled,enabled"
  textline ""
  bitfld.long 0 29. "    BMP_TBUF_EMP        ," "disabled,enabled"
  textline ""
  bitfld.long 0 30. "    BMP_RBUF_FULL       ," "disabled,enabled"
  textline ""
  bitfld.long 0 31. "    SW4                 ," "disabled,enabled"
tree.end

tree.close "SET_CH_MASK1"
wgroup 0x03c++0x4
 textline ""
 line.long 0 "SET_CH_MASK1"
  textline "    KPD                 "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<0.)"
  textline "    SEC                 "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<1.)"
  textline "    GDMAC_ERR           "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<2.)"
  textline "    GDMAC_DMA           "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<3.)"
  textline "    RCNTRL              "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<4.)"
  textline "    EXTERNAL_REQUEST0   "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<5.)"
  textline "    EXTERNAL_REQUEST1   "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<6.)"
  textline "    EXTERNAL_REQUEST2   "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<7.)"
  textline "    EXTERNAL_REQUEST3   "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<8.)"
  textline "    EXTERNAL_REQUEST4   "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<9.)"
  textline "    EXTERNAL_REQUEST5   "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<10.)"
  textline "    EXTERNAL_REQUEST6   "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<11.)"
  textline "    EXTERNAL_REQUEST7   "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<12.)"
  textline "    EXTERNAL_REQUEST8   "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<13.)"
  textline "    EXTERNAL_REQUEST9   "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<14.)"
  textline "    SW1                 "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<15.)"
  textline "    EXTERNAL_REQUEST10  "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<16.)"
  textline "    EXTERNAL_REQUEST11  "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<17.)"
  textline "    EXTERNAL_REQUEST12  "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<18.)"
  textline "    EXTERNAL_REQUEST13  "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<19.)"
  textline "    EXTERNAL_REQUEST14  "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<20.)"
  textline "    EXTERNAL_REQUEST15  "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<21.)"
  textline "    WADPCM              "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<22.)"
  textline "    ADPCM2              "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<23.)"
  textline "    ADPCM1              "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<24.)"
  textline "    RTC                 "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<25.)"
  textline "    APB_TIMER3          "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<26.)"
  textline "    APB_TIMER2          "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<27.)"
  textline "    APB_TIMER1          "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<28.)"
  textline "    TDM3                "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<29.)"
  textline "    TDM2                "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<30.)"
  textline "    SW2                 "
  button "enable" "D.S 0x08a0003c %LE %LONG (1.<<31.)"
tree.end

tree.close "SET_CH_MASK2"
wgroup 0x040++0x4
 textline ""
 line.long 0 "SET_CH_MASK2"
  textline "    TDM1                "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<0.)"
  textline "    SPI2                "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<1.)"
  textline "    SPI1                "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<2.)"
  textline "    CSS_TIMER1          "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<3.)"
  textline "    UART3               "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<4.)"
  textline "    UART2               "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<5.)"
  textline "    UART1               "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<6.)"
  textline "    I2C2                "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<7.)"
  textline "    I2C1                "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<8.)"
  textline "    CSS_TIMER0          "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<9.)"
  textline "    BMP_BCNT1           "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<10.)"
  textline "    BMP_BCNT0           "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<11.)"
  textline "    BMP_MCU_IRQ1        "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<12.)"
  textline "    BMP_BMPTIME         "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<13.)"
  textline "    BMP_MCU_IRQ0        "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<14.)"
  textline "    SW3                 "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<15.)"
  textline "    BMP_RCU_IRQ         "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<16.)"
  textline "    BMP_TCU_IRQ         "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<17.)"
  textline "    BMP_SYNC_DET        "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<18.)"
  textline "    BMP_BCNT_S1         "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<19.)"
  textline "    BMP_BCNT_S0         "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<20.)"
  textline "    PACP                "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<21.)"
  textline "    BMP_FSI             "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<22.)"
  textline "    BMP_MCU_FIQ0        "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<23.)"
  textline "    BMP_SIF             "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<24.)"
  textline "    BMP_RFCU            "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<25.)"
  textline "    BMP_MCU_FIQ1        "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<26.)"
  textline "    BMP_TCU_FIQ         "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<27.)"
  textline "    BMP_RCU_FIQ         "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<28.)"
  textline "    BMP_TBUF_EMP        "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<29.)"
  textline "    BMP_RBUF_FULL       "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<30.)"
  textline "    SW4                 "
  button "enable" "D.S 0x08a00040 %LE %LONG (1.<<31.)"
tree.end

tree.close "CLR_CH_MASK1"
wgroup 0x044++0x4
 textline ""
 line.long 0 "CLR_CH_MASK1"
  textline "    KPD                 "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<0.)"
  textline "    SEC                 "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<1.)"
  textline "    GDMAC_ERR           "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<2.)"
  textline "    GDMAC_DMA           "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<3.)"
  textline "    RCNTRL              "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<4.)"
  textline "    EXTERNAL_REQUEST0   "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<5.)"
  textline "    EXTERNAL_REQUEST1   "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<6.)"
  textline "    EXTERNAL_REQUEST2   "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<7.)"
  textline "    EXTERNAL_REQUEST3   "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<8.)"
  textline "    EXTERNAL_REQUEST4   "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<9.)"
  textline "    EXTERNAL_REQUEST5   "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<10.)"
  textline "    EXTERNAL_REQUEST6   "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<11.)"
  textline "    EXTERNAL_REQUEST7   "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<12.)"
  textline "    EXTERNAL_REQUEST8   "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<13.)"
  textline "    EXTERNAL_REQUEST9   "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<14.)"
  textline "    SW1                 "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<15.)"
  textline "    EXTERNAL_REQUEST10  "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<16.)"
  textline "    EXTERNAL_REQUEST11  "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<17.)"
  textline "    EXTERNAL_REQUEST12  "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<18.)"
  textline "    EXTERNAL_REQUEST13  "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<19.)"
  textline "    EXTERNAL_REQUEST14  "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<20.)"
  textline "    EXTERNAL_REQUEST15  "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<21.)"
  textline "    WADPCM              "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<22.)"
  textline "    ADPCM2              "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<23.)"
  textline "    ADPCM1              "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<24.)"
  textline "    RTC                 "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<25.)"
  textline "    APB_TIMER3          "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<26.)"
  textline "    APB_TIMER2          "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<27.)"
  textline "    APB_TIMER1          "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<28.)"
  textline "    TDM3                "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<29.)"
  textline "    TDM2                "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<30.)"
  textline "    SW2                 "
  button "disable" "D.S 0x08a00044 %LE %LONG (1.<<31.)"
tree.end

tree.close "CLR_CH_MASK2"
wgroup 0x048++0x4
 textline ""
 line.long 0 "CLR_CH_MASK2"
  textline "    TDM1                "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<0.)"
  textline "    SPI2                "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<1.)"
  textline "    SPI1                "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<2.)"
  textline "    CSS_TIMER1          "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<3.)"
  textline "    UART3               "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<4.)"
  textline "    UART2               "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<5.)"
  textline "    UART1               "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<6.)"
  textline "    I2C2                "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<7.)"
  textline "    I2C1                "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<8.)"
  textline "    CSS_TIMER0          "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<9.)"
  textline "    BMP_BCNT1           "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<10.)"
  textline "    BMP_BCNT0           "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<11.)"
  textline "    BMP_MCU_IRQ1        "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<12.)"
  textline "    BMP_BMPTIME         "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<13.)"
  textline "    BMP_MCU_IRQ0        "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<14.)"
  textline "    SW3                 "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<15.)"
  textline "    BMP_RCU_IRQ         "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<16.)"
  textline "    BMP_TCU_IRQ         "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<17.)"
  textline "    BMP_SYNC_DET        "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<18.)"
  textline "    BMP_BCNT_S1         "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<19.)"
  textline "    BMP_BCNT_S0         "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<20.)"
  textline "    PACP                "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<21.)"
  textline "    BMP_FSI             "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<22.)"
  textline "    BMP_MCU_FIQ0        "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<23.)"
  textline "    BMP_SIF             "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<24.)"
  textline "    BMP_RFCU            "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<25.)"
  textline "    BMP_MCU_FIQ1        "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<26.)"
  textline "    BMP_TCU_FIQ         "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<27.)"
  textline "    BMP_RCU_FIQ         "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<28.)"
  textline "    BMP_TBUF_EMP        "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<29.)"
  textline "    BMP_RBUF_FULL       "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<30.)"
  textline "    SW4                 "
  button "disable" "D.S 0x08a00048 %LE %LONG (1.<<31.)"
tree.end

tree.close "CH_PRIORITY"
group 0x04c++0x4
 line.long 0 "CH_PRIORITY1"
  textline ""
  bitfld.long 0   0.--3.  "    KPD                 ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0   4.--7.  "    SEC                 ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0   8.--11. "    GDMAC_ERR           ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  12.--15. "    GDMAC_DMA           ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  16.--19. "    RCNTRL              ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  20.--23. "    EXTERNAL_REQUEST0   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  24.--27. "    EXTERNAL_REQUEST1   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  28.--31. "    EXTERNAL_REQUEST2   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group 0x050++0x4
 line.long 0 "CH_PRIORITY2"
  textline ""
  bitfld.long 0   0.--3.  "    EXTERNAL_REQUEST3   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0   4.--7.  "    EXTERNAL_REQUEST4   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0   8.--11. "    EXTERNAL_REQUEST5   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  12.--15. "    EXTERNAL_REQUEST6   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  16.--19. "    EXTERNAL_REQUEST7   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  20.--23. "    EXTERNAL_REQUEST8   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  24.--27. "    EXTERNAL_REQUEST9   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  28.--31. "    SW1                 ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group 0x054++0x4
 line.long 0 "CH_PRIORITY3"
  textline ""
  bitfld.long 0   0.--3.  "    EXTERNAL_REQUEST10  ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0   4.--7.  "    EXTERNAL_REQUEST11  ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0   8.--11. "    EXTERNAL_REQUEST12  ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  12.--15. "    EXTERNAL_REQUEST13  ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  16.--19. "    EXTERNAL_REQUEST14  ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  20.--23. "    EXTERNAL_REQUEST15  ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  24.--27. "    WADPCM              ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  28.--31. "    ADPCM2              ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group 0x058++0x4
 line.long 0 "CH_PRIORITY4"
  textline ""
  bitfld.long 0   0.--3.  "    ADPCM1              ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0   4.--7.  "    RTC                 ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0   8.--11. "    APB_TIMER3          ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  12.--15. "    APB_TIMER2          ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  16.--19. "    APB_TIMER1          ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  20.--23. "    TDM3                ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  24.--27. "    TDM2                ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  28.--31. "    SW2                 ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group 0x05c++0x4
 line.long 0 "CH_PRIORITY5"
  textline ""
  bitfld.long 0   0.--3.  "    TDM1                ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0   4.--7.  "    SPI2                ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0   8.--11. "    SPI1                ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  12.--15. "    CSS_TIMER1          ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  16.--19. "    UART3               ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  20.--23. "    UART2               ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  24.--27. "    UART1               ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  28.--31. "    I2C2                ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group 0x060++0x4
 line.long 0 "CH_PRIORITY6"
  textline ""
  bitfld.long 0   0.--3.  "    I2C1                ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0   4.--7.  "    CSS_TIMER0          ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0   8.--11. "    BMP_BCNT1           ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  12.--15. "    BMP_BCNT0           ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  16.--19. "    BMP_MCU_IRQ1        ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  20.--23. "    BMP_BMPTIME         ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  24.--27. "    BMP_MCU_IRQ0        ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  28.--31. "    SW3                 ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group 0x064++0x4
 line.long 0 "CH_PRIORITY7"
  textline ""
  bitfld.long 0   0.--3.  "    BMP_RCU_IRQ         ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0   4.--7.  "    BMP_TCU_IRQ         ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0   8.--11. "    BMP_SYNC_DET        ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  12.--15. "    BMP_BCNT_S1         ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  16.--19. "    BMP_BCNT_S0         ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  20.--23. "    PACP                ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  24.--27. "    BMP_FSI             ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  28.--31. "    BMP_MCU_FIQ0        ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group 0x068++0x4
 line.long 0 "CH_PRIORITY8"
  textline ""
  bitfld.long 0   0.--3.  "    BMP_SIF             ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0   4.--7.  "    BMP_RFCU            ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0   8.--11. "    BMP_MCU_FIQ1        ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  12.--15. "    BMP_TCU_FIQ         ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  16.--19. "    BMP_RCU_FIQ         ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  20.--23. "    BMP_TBUF_EMP        ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  textline ""
  bitfld.long 0  24.--27. "    BMP_RBUF_FULL       ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long 0  28.--31. "    SW4                 ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
tree.end

tree.close "FIQ_SEL1"
group 0x06c++0x4
  textline ""
  bitfld.long 0  0. "    KPD                 ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  1. "    SEC                 ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  2. "    GDMAC_ERR           ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  3. "    GDMAC_DMA           ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  4. "    RCNTRL              ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  5. "    EXTERNAL_REQUEST0   ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  6. "    EXTERNAL_REQUEST1   ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  7. "    EXTERNAL_REQUEST2   ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  8. "    EXTERNAL_REQUEST3   ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  9. "    EXTERNAL_REQUEST4   ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 10. "    EXTERNAL_REQUEST5   ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 11. "    EXTERNAL_REQUEST6   ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 12. "    EXTERNAL_REQUEST7   ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 13. "    EXTERNAL_REQUEST8   ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 14. "    EXTERNAL_REQUEST9   ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 15. "    SW1                 ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 16. "    EXTERNAL_REQUEST10  ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 17. "    EXTERNAL_REQUEST11  ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 18. "    EXTERNAL_REQUEST12  ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 19. "    EXTERNAL_REQUEST13  ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 20. "    EXTERNAL_REQUEST14  ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 21. "    EXTERNAL_REQUEST15  ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 22. "    WADPCM              ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 23. "    ADPCM2              ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 24. "    ADPCM1              ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 25. "    RTC                 ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 26. "    APB_TIMER3          ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 27. "    APB_TIMER2          ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 28. "    APB_TIMER1          ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 29. "    TDM3                ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 30. "    TDM2                ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 31. "    SW2                 ," "IRQ,_FIQ_"
tree.end
tree.close "FIQ_SEL2"
group 0x070++0x4
  textline ""
  bitfld.long 0  0. "    TDM1                ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  1. "    SPI2                ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  2. "    SPI1                ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  3. "    CSS_TIMER1          ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  4. "    UART3               ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  5. "    UART2               ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  6. "    UART1               ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  7. "    I2C2                ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  8. "    I2C1                ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0  9. "    CSS_TIMER0          ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 10. "    BMP_BCNT1           ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 11. "    BMP_BCNT0           ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 12. "    BMP_MCU_IRQ1        ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 13. "    BMP_BMPTIME         ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 14. "    BMP_MCU_IRQ0        ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 15. "    SW3                 ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 16. "    BMP_RCU_IRQ         ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 17. "    BMP_TCU_IRQ         ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 18. "    BMP_SYNC_DET        ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 19. "    BMP_BCNT_S1         ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 20. "    BMP_BCNT_S0         ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 21. "    PACP                ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 22. "    BMP_FSI             ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 23. "    BMP_MCU_FIQ0        ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 24. "    BMP_SIF             ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 25. "    BMP_RFCU            ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 26. "    BMP_MCU_FIQ1        ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 27. "    BMP_TCU_FIQ         ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 28. "    BMP_RCU_FIQ         ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 29. "    BMP_TBUF_EMP        ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 30. "    BMP_RBUF_FULL       ," "IRQ,_FIQ_"
  textline ""
  bitfld.long 0 31. "    SW4                 ," "IRQ,_FIQ_"
tree.end
tree.close "FIQ_PENDING_REQ1"
rgroup 0x070--0x073
  textline ""
  bitfld.long 0  0. "    KPD                 ," "not_pending,pending"
  textline ""
  bitfld.long 0  1. "    SEC                 ," "not_pending,pending"
  textline ""
  bitfld.long 0  2. "    GDMAC_ERR           ," "not_pending,pending"
  textline ""
  bitfld.long 0  3. "    GDMAC_DMA           ," "not_pending,pending"
  textline ""
  bitfld.long 0  4. "    RCNTRL              ," "not_pending,pending"
  textline ""
  bitfld.long 0  5. "    EXTERNAL_REQUEST0   ," "not_pending,pending"
  textline ""
  bitfld.long 0  6. "    EXTERNAL_REQUEST1   ," "not_pending,pending"
  textline ""
  bitfld.long 0  7. "    EXTERNAL_REQUEST2   ," "not_pending,pending"
  textline ""
  bitfld.long 0  8. "    EXTERNAL_REQUEST3   ," "not_pending,pending"
  textline ""
  bitfld.long 0  9. "    EXTERNAL_REQUEST4   ," "not_pending,pending"
  textline ""
  bitfld.long 0 10. "    EXTERNAL_REQUEST5   ," "not_pending,pending"
  textline ""
  bitfld.long 0 11. "    EXTERNAL_REQUEST6   ," "not_pending,pending"
  textline ""
  bitfld.long 0 12. "    EXTERNAL_REQUEST7   ," "not_pending,pending"
  textline ""
  bitfld.long 0 13. "    EXTERNAL_REQUEST8   ," "not_pending,pending"
  textline ""
  bitfld.long 0 14. "    EXTERNAL_REQUEST9   ," "not_pending,pending"
  textline ""
  bitfld.long 0 15. "    SW1                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 16. "    EXTERNAL_REQUEST10  ," "not_pending,pending"
  textline ""
  bitfld.long 0 17. "    EXTERNAL_REQUEST11  ," "not_pending,pending"
  textline ""
  bitfld.long 0 18. "    EXTERNAL_REQUEST12  ," "not_pending,pending"
  textline ""
  bitfld.long 0 19. "    EXTERNAL_REQUEST13  ," "not_pending,pending"
  textline ""
  bitfld.long 0 20. "    EXTERNAL_REQUEST14  ," "not_pending,pending"
  textline ""
  bitfld.long 0 21. "    EXTERNAL_REQUEST15  ," "not_pending,pending"
  textline ""
  bitfld.long 0 22. "    WADPCM              ," "not_pending,pending"
  textline ""
  bitfld.long 0 23. "    ADPCM2              ," "not_pending,pending"
  textline ""
  bitfld.long 0 24. "    ADPCM1              ," "not_pending,pending"
  textline ""
  bitfld.long 0 25. "    RTC                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 26. "    APB_TIMER3          ," "not_pending,pending"
  textline ""
  bitfld.long 0 27. "    APB_TIMER2          ," "not_pending,pending"
  textline ""
  bitfld.long 0 28. "    APB_TIMER1          ," "not_pending,pending"
  textline ""
  bitfld.long 0 29. "    TDM3                ," "not_pending,pending"
  textline ""
  bitfld.long 0 30. "    TDM2                ," "not_pending,pending"
  textline ""
  bitfld.long 0 31. "    SW2                 ," "not_pending,pending"
tree.end
tree.close "FIQ_PENDING_REQ2"
rgroup 0x074--0x077
  textline ""
  bitfld.long 0  0. "    TDM1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  1. "    SPI2                ," "not_pending,pending"
  textline ""
  bitfld.long 0  2. "    SPI1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  3. "    CSS_TIMER1          ," "not_pending,pending"
  textline ""
  bitfld.long 0  4. "    UART3               ," "not_pending,pending"
  textline ""
  bitfld.long 0  5. "    UART2               ," "not_pending,pending"
  textline ""
  bitfld.long 0  6. "    UART1               ," "not_pending,pending"
  textline ""
  bitfld.long 0  7. "    I2C2                ," "not_pending,pending"
  textline ""
  bitfld.long 0  8. "    I2C1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  9. "    CSS_TIMER0          ," "not_pending,pending"
  textline ""
  bitfld.long 0 10. "    BMP_BCNT1           ," "not_pending,pending"
  textline ""
  bitfld.long 0 11. "    BMP_BCNT0           ," "not_pending,pending"
  textline ""
  bitfld.long 0 12. "    BMP_MCU_IRQ1        ," "not_pending,pending"
  textline ""
  bitfld.long 0 13. "    BMP_BMPTIME         ," "not_pending,pending"
  textline ""
  bitfld.long 0 14. "    BMP_MCU_IRQ0        ," "not_pending,pending"
  textline ""
  bitfld.long 0 15. "    SW3                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 16. "    BMP_RCU_IRQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 17. "    BMP_TCU_IRQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 18. "    BMP_SYNC_DET        ," "not_pending,pending"
  textline ""
  bitfld.long 0 19. "    BMP_BCNT_S1         ," "not_pending,pending"
  textline ""
  bitfld.long 0 20. "    BMP_BCNT_S0         ," "not_pending,pending"
  textline ""
  bitfld.long 0 21. "    PACP                ," "not_pending,pending"
  textline ""
  bitfld.long 0 22. "    BMP_FSI             ," "not_pending,pending"
  textline ""
  bitfld.long 0 23. "    BMP_MCU_FIQ0        ," "not_pending,pending"
  textline ""
  bitfld.long 0 24. "    BMP_SIF             ," "not_pending,pending"
  textline ""
  bitfld.long 0 25. "    BMP_RFCU            ," "not_pending,pending"
  textline ""
  bitfld.long 0 26. "    BMP_MCU_FIQ1        ," "not_pending,pending"
  textline ""
  bitfld.long 0 27. "    BMP_TCU_FIQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 28. "    BMP_RCU_FIQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 29. "    BMP_TBUF_EMP        ," "not_pending,pending"
  textline ""
  bitfld.long 0 30. "    BMP_RBUF_FULL       ," "not_pending,pending"
  textline ""
  bitfld.long 0 31. "    SW4                 ," "not_pending,pending"
tree.end
tree.close "FIQ_CAUSE1"
rgroup 0x07c++0x4
  textline ""
  bitfld.long 0  0. "    KPD                 ," "not_pending,pending"
  textline ""
  bitfld.long 0  1. "    SEC                 ," "not_pending,pending"
  textline ""
  bitfld.long 0  2. "    GDMAC_ERR           ," "not_pending,pending"
  textline ""
  bitfld.long 0  3. "    GDMAC_DMA           ," "not_pending,pending"
  textline ""
  bitfld.long 0  4. "    RCNTRL              ," "not_pending,pending"
  textline ""
  bitfld.long 0  5. "    EXTERNAL_REQUEST0   ," "not_pending,pending"
  textline ""
  bitfld.long 0  6. "    EXTERNAL_REQUEST1   ," "not_pending,pending"
  textline ""
  bitfld.long 0  7. "    EXTERNAL_REQUEST2   ," "not_pending,pending"
  textline ""
  bitfld.long 0  8. "    EXTERNAL_REQUEST3   ," "not_pending,pending"
  textline ""
  bitfld.long 0  9. "    EXTERNAL_REQUEST4   ," "not_pending,pending"
  textline ""
  bitfld.long 0 10. "    EXTERNAL_REQUEST5   ," "not_pending,pending"
  textline ""
  bitfld.long 0 11. "    EXTERNAL_REQUEST6   ," "not_pending,pending"
  textline ""
  bitfld.long 0 12. "    EXTERNAL_REQUEST7   ," "not_pending,pending"
  textline ""
  bitfld.long 0 13. "    EXTERNAL_REQUEST8   ," "not_pending,pending"
  textline ""
  bitfld.long 0 14. "    EXTERNAL_REQUEST9   ," "not_pending,pending"
  textline ""
  bitfld.long 0 15. "    SW1                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 16. "    EXTERNAL_REQUEST10  ," "not_pending,pending"
  textline ""
  bitfld.long 0 17. "    EXTERNAL_REQUEST11  ," "not_pending,pending"
  textline ""
  bitfld.long 0 18. "    EXTERNAL_REQUEST12  ," "not_pending,pending"
  textline ""
  bitfld.long 0 19. "    EXTERNAL_REQUEST13  ," "not_pending,pending"
  textline ""
  bitfld.long 0 20. "    EXTERNAL_REQUEST14  ," "not_pending,pending"
  textline ""
  bitfld.long 0 21. "    EXTERNAL_REQUEST15  ," "not_pending,pending"
  textline ""
  bitfld.long 0 22. "    WADPCM              ," "not_pending,pending"
  textline ""
  bitfld.long 0 23. "    ADPCM2              ," "not_pending,pending"
  textline ""
  bitfld.long 0 24. "    ADPCM1              ," "not_pending,pending"
  textline ""
  bitfld.long 0 25. "    RTC                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 26. "    APB_TIMER3          ," "not_pending,pending"
  textline ""
  bitfld.long 0 27. "    APB_TIMER2          ," "not_pending,pending"
  textline ""
  bitfld.long 0 28. "    APB_TIMER1          ," "not_pending,pending"
  textline ""
  bitfld.long 0 29. "    TDM3                ," "not_pending,pending"
  textline ""
  bitfld.long 0 30. "    TDM2                ," "not_pending,pending"
  textline ""
  bitfld.long 0 31. "    SW2                 ," "not_pending,pending"
tree.end
tree.close "FIQ_CAUSE2"
rgroup 0x080++0x4
  textline ""
  bitfld.long 0  0. "    TDM1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  1. "    SPI2                ," "not_pending,pending"
  textline ""
  bitfld.long 0  2. "    SPI1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  3. "    CSS_TIMER1          ," "not_pending,pending"
  textline ""
  bitfld.long 0  4. "    UART3               ," "not_pending,pending"
  textline ""
  bitfld.long 0  5. "    UART2               ," "not_pending,pending"
  textline ""
  bitfld.long 0  6. "    UART1               ," "not_pending,pending"
  textline ""
  bitfld.long 0  7. "    I2C2                ," "not_pending,pending"
  textline ""
  bitfld.long 0  8. "    I2C1                ," "not_pending,pending"
  textline ""
  bitfld.long 0  9. "    CSS_TIMER0          ," "not_pending,pending"
  textline ""
  bitfld.long 0 10. "    BMP_BCNT1           ," "not_pending,pending"
  textline ""
  bitfld.long 0 11. "    BMP_BCNT0           ," "not_pending,pending"
  textline ""
  bitfld.long 0 12. "    BMP_MCU_IRQ1        ," "not_pending,pending"
  textline ""
  bitfld.long 0 13. "    BMP_BMPTIME         ," "not_pending,pending"
  textline ""
  bitfld.long 0 14. "    BMP_MCU_IRQ0        ," "not_pending,pending"
  textline ""
  bitfld.long 0 15. "    SW3                 ," "not_pending,pending"
  textline ""
  bitfld.long 0 16. "    BMP_RCU_IRQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 17. "    BMP_TCU_IRQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 18. "    BMP_SYNC_DET        ," "not_pending,pending"
  textline ""
  bitfld.long 0 19. "    BMP_BCNT_S1         ," "not_pending,pending"
  textline ""
  bitfld.long 0 20. "    BMP_BCNT_S0         ," "not_pending,pending"
  textline ""
  bitfld.long 0 21. "    PACP                ," "not_pending,pending"
  textline ""
  bitfld.long 0 22. "    BMP_FSI             ," "not_pending,pending"
  textline ""
  bitfld.long 0 23. "    BMP_MCU_FIQ0        ," "not_pending,pending"
  textline ""
  bitfld.long 0 24. "    BMP_SIF             ," "not_pending,pending"
  textline ""
  bitfld.long 0 25. "    BMP_RFCU            ," "not_pending,pending"
  textline ""
  bitfld.long 0 26. "    BMP_MCU_FIQ1        ," "not_pending,pending"
  textline ""
  bitfld.long 0 27. "    BMP_TCU_FIQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 28. "    BMP_RCU_FIQ         ," "not_pending,pending"
  textline ""
  bitfld.long 0 29. "    BMP_TBUF_EMP        ," "not_pending,pending"
  textline ""
  bitfld.long 0 30. "    BMP_RBUF_FULL       ," "not_pending,pending"
  textline ""
  bitfld.long 0 31. "    SW4                 ," "not_pending,pending"
tree.end

group 0x084++0x4
 line.long 0 "PRI_MASK_IRQ"
  textline ""
  bitfld.long 0   0.--4.  "    MIN_IRQ_PRIORITY    ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group 0x088++0x4
 line.long 0 "PRI_MASK_FIQ"
  textline ""
  bitfld.long 0   0.--4.  "    MIN_FIQ_PRIORITY    ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

tree.end

;=====================================================
tree "SEC      - Semaphores Exchange Center"
;=====================================================
base a:0x00a00000
rgroup 0x600--0x603
 line.long 0 "CPU2COM_STAT1"
rgroup 0x604--0x607
 line.long 0 "CPU2COM_STAT2"
rgroup 0x608--0x60B
 line.long 0 "CPU2COM_MASK1"
rgroup 0x60C--0x60F
 hide.long 0 "CPU2COM_MASK2"
rgroup 0x610--0x613
 line.long 0 "CPU2COM_OVR1"
rgroup 0x614--0x617
 line.long 0 "CPU2COM_OVR2"
rgroup 0x618--0x61B
 line.long 0 "CPU2COM_CAUS1"
rgroup 0x61C--0x61F
 line.long 0 "CPU2COM_CAUS2"
rgroup 0x620--0x623
 line.long 0 "CPU_CAUSE"
  textline ""
  bitfld.long 0 0. "    COM1_REQ ," " 0, 1 "
  textline ""
  bitfld.long 0 1. "    COM2_REQ ," " 0, 1 "
rgroup 0x640--0x643
 line.long 0 "COM2CPU_STAT1"
rgroup 0x644--0x647
 line.long 0 "COM2CPU_STAT2"
rgroup 0x648--0x64B
 line.long 0 "COM2CPU_MASK1"
rgroup 0x64C--0x64F
 hide.long 0 "COM2CPU_MASK2"
rgroup 0x650--0x653
 line.long 0 "COM2CPU_OVR1"
rgroup 0x654--0x657
 line.long 0 "COM2CPU_OVR2"
rgroup 0x658--0x65B
 line.long 0 "COM2CPU_CAUS1"
rgroup 0x65C--0x65F
 line.long 0 "COM2CPU_CAUS2"
rgroup 0x660--0x663
 line.long 0 "COM_CAUSE"
  textline ""
  bitfld.long 0 0. "    CPU1_REQ ," " 0, 1 "
  textline ""
  bitfld.long 0 1. "    CPU2_REQ ," " 0, 1 "
tree.end
